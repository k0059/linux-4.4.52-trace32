; --------------------------------------------------------------------------------
; @Title: Cortex-A5MPCORE On-Chip Peripherals
; @Props: Released
; @Author: PEG
; @Changelog: 2008-09-17 PEG
; @Manufacturer: ARM - ARM Ltd.
; @Doc: DDI0433A_cortex_a5_r0p0_trm.pdf
; @Core: Cortex-A5
; @Chip: CORTEX-A5MPCORE
; @Copyright: (C) 1989-2015 Lauterbach GmbH, licensed for use with TRACE32(R) only
; --------------------------------------------------------------------------------
; $Id: percortexa5mpcore.per 5897 2015-01-09 10:48:24Z askoncej $


config 16. 8.
width 0x0b

width 0x8
; --------------------------------------------------------------------------------
;    Identification registers
; --------------------------------------------------------------------------------
tree "ID Registers"

rgroup.long c15:0x0++0x0
    line.long 0x0 "MIDR,Main ID Register"
        hexmask.long.byte 0x0 24.--31. 0x1 " IMPL       ,Implementer code"
        bitfld.long 0x0 20.--23.  "              VAR        ,Variant" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x0 16.--19.  "             ARCH      , Architecture" "Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,Pre-ARMv7,ARMv7"
        textline "                 "
        hexmask.long.word 0x0 4.--15. 0x1 " PART       ,Primary Part Number"
        bitfld.long 0x0 0.--3. "            REV        ,Revision Number" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

rgroup.long c15:0x100++0x0
    line.long 0x0 "CTR,Cache Type Register"
        bitfld.long 0x0 29.--31. " FORMAT     ,Format" "Not ARMv7,Not ARMv7,Not ARMv7,Not ARMv7,ARMv7,Not ARMv7,Not ARMv7,Not ARMv7"
        bitfld.long 0x0 24.--27. "       CWG        ,Cache Writeback Granule" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                 "
        bitfld.long 0x0 20.--23. " ERG        ,Exclusives Reservation Granule" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x0 16.--19. "              DMINLINE   ,D-Cache Minimum Line Size" "1 word,2 words,4 words,8 words,16 words,32 words,64 words,128 words,256 words,512 words,1024 words,2048 words,4096 words,8192 words,16384 words,32768 words"
        textline "                 "
        bitfld.long 0x0 14.--15. " L1POLICY   ,L1 Instruction cache policy" "Reserved,ASID,Virtual,Physical"
        bitfld.long 0x0 0.--3. "        IMINLINE   ,I-Cache Minimum Line Size" "1 word,2 words,4 words,8 words,16 words,32 words,64 words,128 words,256 words,512 words,1024 words,2048 words,4096 words,8192 words,16384 words,32768 words"

rgroup.long c15:0x200++0x0
    line.long 0x0 "TCMTR,Tighly-Coupled Memory Type Register"

rgroup.long c15:0x300++0x0
    line.long 0x0 "TLBTR,TLB Type Register"
        hexmask.long.byte 0x0 16.--23. 0x1 " ILSIZE     ,Specifies the number of instruction TLB lockable entries"
        hexmask.long.byte 0x0 8.--15. 0x1 "              DLSIZE     ,Specifies the number of unified or data TLB lockable entries"
        bitfld.long 0x0 1. "             TLB_size  ,TLB Size" "64,128"
        textline "                 "
        bitfld.long 0x0 0. " nU         ,Unified or Separate TLBs" "Unified,Separate"
  
rgroup.long c15:0x500++0x0
    line.long 0x0 "MPIDR,Multiprocessor Affinity Register"
        bitfld.long 0x00 30. " U          ,Processor is part of a multiprocessor or uniprocessor system" "Multiprocessor,Uniprocessor"
        bitfld.long 0x00 8.--11. "  ClusterID  ,Value read in CLUSTERID configuration pins" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--1. "             CPUID     ,Value depends on the number of configured CPUs" "0,1,2,3"

rgroup.long c15:0x0410++0x00
    line.long 0x00 "MMFR0,Memory Model Feature Register 0"
        bitfld.long 0x00 24.--27. " FCSE       ,Fast Context Switch Memory Mappings Support" "Not supported,?..."
        bitfld.long 0x00 20.--23. "   ACR        ,Auxiliary Control Register Support" "Reserved,Supported,?..."
        bitfld.long 0x00 16.--19. "      TCM       ,TCM and Associated DMA Support" "Not supported,?..."
        textline "                 "
          bitfld.long 0x00 12.--15. " OSS        ,Outer Shareable Support" "Not supported,?..."
        bitfld.long 0x00 8.--11. "   CC_CPUA    ,Cache Coherency Support" "Reserved,Supported,?..."
        bitfld.long 0x00 4.--7. "      PMSA      ,Physical Memory System Architecture (PMSA) Support" "Not supported,?..."
        textline "                 "
        bitfld.long 0x00 0.--3. " VMSA       ,Virtual Memory System Architecture (VMSA) Support" "Reserved,Reserved,Reserved,Supported,?..."            
rgroup.long c15:0x0510++0x00
    line.long 0x00 "MMFR1,Memory Model Feature Register 1"
        bitfld.long 0x00 28.--31. " BTB        ,Branch Predictor" "Reserved,Reserved,Required,?..."
        bitfld.long 0x00 24.--27. "        L1TCO      ,Test and Clean Operations on Data Cache/Harvard/Unified Architecture Support" "Not supported,?..."
        bitfld.long 0x00 20.--23. "  L1UCMO    ,L1 Cache/All Maintenance Operations/Unified Architecture Support" "Not supported,?..."
        textline "                 "
        bitfld.long 0x00 16.--19. " L1HCMO     ,L1 Cache/All Maintenance Operations/Harvard Architecture Support" "Not supported,?..."
        bitfld.long 0x00 12.--15. "   L1UCLMOSW  ,L1 Cache Line Maintenance Operations by Set and Way/Unified Architecture Support" "Not supported,?..."
        bitfld.long 0x00 8.--11. "  L1HCLMOSW ,L1 Cache Line Maintenance Operations by Set and Way/Harvard Architecture Support" "Not supported,?..."
        textline "                 "
        bitfld.long 0x00 4.--7. " L1UCLMOMVA ,L1 Cache Line Maintenance Operations by VA/Unified Architecture Support" "Not supported,?..."
        bitfld.long 0x00 0.--3. "   L1HCLMOMVA ,L1 Cache Line Maintenance Operations by VA/Harvard Architecture" "Not supported,?..."    
rgroup.long c15:0x0610++0x00
    line.long 0x00 "MMFR2,Memory Model Feature Register 2"
        bitfld.long 0x00 28.--31. " HAF        ,Hardware Access Flag Support" "Not supported,?..."
        bitfld.long 0x00 24.--27. "   WFI        ,Wait for Interrupt Stalling Support" "Reserved,Supported,?..."
        bitfld.long 0x00 20.--23. "      MBF       ,Memory Barrier Operations Support" "Reserved,Reserved,Supported,?..."
        textline "                 "
        bitfld.long 0x00 16.--19. " UTLBMO     ,TLB Maintenance Operations/Unified Architecture Support" "Reserved,Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 12.--15. "       HTLBMO     ,TLB Maintenance Operations/Harvard Architecture Support" "Not supported,?..."
        bitfld.long 0x00 8.--11. "  HL1CMRO   ,Cache Maintenance Range Operations/Harvard Architecture Support" "Not supported,?..."
        textline "                 "
        bitfld.long 0x00 4.--7. " HL1BPCRO   ,Background Prefetch Cache Range Operations/Harvard Architecture Support" "Not supported,?..."
        bitfld.long 0x00 0.--3. "   HL1FPCRO   ,Foreground Prefetch Cache Range Operations/Harvard Architecture Support" "Not supported,?..."
rgroup.long c15:0x0710++0x00
    line.long 0x00 "MMFR3,Memory Model Feature Register 3"
        bitfld.long 0x00 28.--31. " SS         ,Supersection support" "Supported,?..."
        bitfld.long 0x00 20.--23. "       CW         ,Coherent walk" "Supported,?..."
        bitfld.long 0x00 12.--15. "      MB        ,Invalidate broadcast Support" "Reserved,Reserved,Supported,?..."
        textline "                 "
        bitfld.long 0x00 8.--11. " BPM        ,Invalidate Branch predictor Support" "Reserved,Supported,?..."
        bitfld.long 0x00 4.--7. "       HCMOSW     ,Invalidate Cache by Set and Way/Clean by Set and Way/Invalidate and Clean by Set and Way Support" "Reserved,Supported,?..."
        bitfld.long 0x00 0.--3. "      HCMOMVA   ,Invalidate Cache MVA Support" "Reserved,Supported,?..."                
rgroup.long c15:0x0020++0x00
    line.long 0x00 "ISAR0,Instruction Set Attribute Register 0"
        bitfld.long 0x00 24.--27. " DIVI       ,Divide Instructions Support" "Not supported,?..."
        bitfld.long 0x00 20.--23. "   DEBI       ,Debug Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 16.--19. "      CI        ,Coprocessor Instructions Support" "Not supported,?..."
        textline "                 "
        bitfld.long 0x00 12.--15. " CBI        ,Combined Compare and Branch Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 8.--11. "       BI         ,Bitfield Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 4.--7. "      BCI       ,Bit Counting Instructions Support" "Reserved,Supported,?..."
        textline "                 "
        bitfld.long 0x00 0.--3. " SI         ,Swap Instructions Support" "Reserved,Supported,?..."            
rgroup.long c15:0x0120++0x00
    line.long 0x00 "ISAR1,Instruction Set Attribute Register 1"
        bitfld.long 0x00 28.--31. " JI         ,Jazelle Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 24.--27. "       INTI       ,Interwork Instructions Support" "Reserved,Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 20.--23. "      IMMI      ,Immediate Instructions Support" "Reserved,Supported,?..."
        textline "                 "
        bitfld.long 0x00 16.--19. " ITEI       ,If Then Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 12.--15. "       EXTI       ,Extend Instructions Support" "Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 8.--11. "      E2I       ,Exception 2 Instructions Support" "Reserved,Supported,?..."
        textline "                 "
        bitfld.long 0x00 4.--7. " E1I        ,Exception 1 Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 0.--3. "       ENDI       ,Endian Instructions Support" "Reserved,Supported,?..."            
rgroup.long c15:0x0220++0x00
    line.long 0x00 "ISAR2,Instruction Set Attribute Register 2"
        bitfld.long 0x00 28.--31. " RI         ,Reversal Instructions Support" "Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 24.--27. "       PSRI       ,PSR Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 20.--23. "      UMI       ,Advanced Unsigned Multiply Instructions Support" "Reserved,Reserved,Supported,?..."
        textline "                 "
        bitfld.long 0x00 16.--19. " SMI        ,Advanced Signed Multiply Instructions Support" "Reserved,Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 12.--15. "       MI         ,Multiply Instructions Support" "Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 8.--11. "      II        ,Multi-Access Interruptible Instructions Support" "Not supported,?..."
        textline "                 "
        bitfld.long 0x00 4.--7. " MHI        ,Memory Hint Instructions Support" "Reserved,Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 0.--3. "       LSI        ,Load and Store Instructions Support" "Reserved,Supported,?..."
rgroup.long c15:0x0320++0x00
    line.long 0x00 "ISAR3,Instruction Set Attribute Register 3"
        bitfld.long 0x00 28.--31. " T2E        ,Thumb-2 Extensions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 24.--27. "       NOPI       ,True NOP Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 20.--23. "      TCI       ,Thumb Copy Instructions Support" "Reserved,Supported,?..."
        textline "                 "
        bitfld.long 0x00 16.--19. " TBI        ,Table Branch Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 12.--15. "       SPI        ,Synchronization Primitive Instructions Support" "Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 8.--11. "      SVCI      ,SVC Instructions Support" "Reserved,Supported,?..."
        textline "                 "
        bitfld.long 0x00 4.--7. " SIMDI      ,Single Instruction Multiple Data (SIMD) Instructions Support" "Reserved,Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 0.--3. "       SI         ,Saturate Instructions Support" "Reserved,Supported,?..."                
rgroup.long c15:0x0420++0x00
    line.long 0x00 "ISAR4,Instruction Set Attribute Register 4"
        bitfld.long 0x00 28.--31. " SWP_frac   ,SWAP_frac" "Supported,?..."
        bitfld.long 0x00 24.--27. "       PSR_M_I    ,PSR_M Instructions Support" "Not supported,?..."
        bitfld.long 0x00 20.--23. "  SPRI      ,Synchronization Primitive instructions" "Not supported,?..."
        textline "                 "
        bitfld.long 0x00 16.--19. " BI         ,Barrier Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 12.--15. "       SMCI       ,SMC Instructions Support" "Reserved,Supported,?..."
        bitfld.long 0x00 8.--11. "      WBI       ,Write-Back Instructions Support" "Reserved,Supported,?..."
          textline "                 "
        bitfld.long 0x00 4.--7. " WSI        ,With-Shift Instructions Support" "Reserved,Reserved,Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 0.--3. "       UI         ,Unprivileged Instructions Support" "Reserved,Reserved,Supported,?..."                    
rgroup.long c15:0x0520++0x00
    line.long 0x00 "ISAR5,Instruction Set Attribute Registers 5 (Reserved)"
rgroup.long c15:0x0620++0x00
    line.long 0x00 "ISAR6,Instruction Set Attribute Registers 6 (Reserved)"
rgroup.long c15:0x0720++0x00
    line.long 0x00 "ISAR7,Instruction Set Attribute Registers 7 (Reserved)"            
rgroup.long c15:0x0010++0x00
    line.long 0x00 "PFR0,Processor Feature Register 0"
        bitfld.long 0x00 12.--15. " State3     ,Thumb-2 Execution Environment (Thumb-2EE) Support" "Reserved,Supported,?..."
        bitfld.long 0x00 8.--11. "       State2     ,Java Extension Interface Support" "Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 4.--7. "      State1    ,Thumb Encoding Supported by the Processor Type" "Reserved,Reserved,Reserved,Supported,?..."
        textline "                 "
        bitfld.long 0x00 0.--3. " State0     ,ARM Instruction Set Support" "Reserved,Supported,?..."
rgroup.long c15:0x0110++0x00
    line.long 0x00 "PFR1,Processor Feature Register 1"
        bitfld.long 0x00 8.--11. " MPM        ,Microcontroller Programmer's Model Support" "Not supported,?..."
        bitfld.long 0x00 4.--7. "   SE         ,Security Extensions Architecture v1 Support" "Reserved,Supported,?..."
        bitfld.long 0x00 0.--3. "      PM        ,Standard ARMv4 Programmer's Model Support" "Reserved,Supported,?..."
rgroup.long c15:0x0210++0x00
    line.long 0x00 "DFR0,Debug Feature Register 0"
        bitfld.long 0x00 20.--23. " MDM_MM     ,Microcontroller Debug Model Support" "Not supported,?..."
        bitfld.long 0x00 16.--19. "   TDM_MM     ,Trace Debug Model (Memory-Mapped) Support" "Reserved,Supported,?..."
        bitfld.long 0x00 12.--15. "      TDM_CB    ,Coprocessor-Based Trace Debug Model Support" "Not supported,?..."
        textline "                 "
        bitfld.long 0x00 8.--11. " CDM_MM     ,Memory-Mapped Debug Model Support" "Reserved,Reserved,Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 4.--7. "       SDM_CB     ,Secure Debug Model (Coprocessor) Support" "Reserved,Reserved,Reserved,Reserved,Supported,?..."
        bitfld.long 0x00 0.--3. "      CDM_CB    ,Coprocessor Debug Model Support" "Reserved,Reserved,Reserved,Reserved,Supported,?..."
rgroup.long c15:0x0310++0x00
    line.long 0x00 "AFR0,Auxiliary Feature Register 0"
        hexmask.long 0x00 0.--31. 1. " AF         ,Auxiliary Feature"
tree.end
width 0x8
tree "System Control and Configuration"

group.long c15:0x1++0x0
    line.long 0x0 "SCTLR,Control Register"
        bitfld.long 0x0 30. " TE       ,Thumb exception enable" "ARM,Thumb"
        bitfld.long 0x0 29. "        AFE    ,Access Flag Enable" "Disabled,Enabled"
        bitfld.long 0x0 28. "      TRE      ,TEX remap enable" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x0 27. " NMFI     ,DNonmaskable Fast Interrupt enable" "Disabled,Enabled"
        bitfld.long 0x0 25. "     EE     ,Exception endianess" "Little,Big"
        bitfld.long 0x0 14. "        RR       ,Replacement strategy for caches, BTAC, and micro TLBs" "Random,Round robin"
        textline "                 "
        bitfld.long 0x0 13. " V        ,Base Location of Exception Registers" "0x00000000,0xFFFF0000"
        bitfld.long 0x0 12. "   I      ,Instruction Cache Enable" "Disabled,Enabled"
        bitfld.long 0x0 11. "      Z        ,Branch Prediction Enable" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x0 10. " SW       ,SWP/SWPB Enable" "Disabled,Enabled"
        bitfld.long 0x0 2. "     C      ,Enable unified cache or data cache" "Disabled,Enabled"
        bitfld.long 0x0 1. "      A        ,Strict Alignment" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x0 0. " M        ,MMU or Protection Unit" "Disabled,Enabled"      
group.long c15:0x101++0x0
    line.long 0x0 "ACTLR,Auxiliary Control Register"
        bitfld.long 0x00 28. " DBDI     ,Disable branch dual issue" "No,Yes"
        bitfld.long 0x00 18. "          BTDIS  ,Disable indirect Branch Target Address Cache" "No,Yes"
        bitfld.long 0x00 17. "           RSDIS    ,Disable return stack operation" "No,Yes"
        textline "                 "
        bitfld.long 0x00 15.--16. " BP       ,Branch prediction policy" "Normal,Taken,Not taken,?..."
        bitfld.long 0x00 13.--14. "    L1PCTL ,L1 Data prefetch control" "Disabled,1 prefetch,2 prefetches,3 prefetches"
        bitfld.long 0x00 12. "  RADIS    ,Disable Data Cache read-allocate mode" "No,Yes"
        textline "                 "
        bitfld.long 0x00 11. " DWBST    ,Disable data write bursts to normal non-cacheable memory" "No,Yes"
        bitfld.long 0x00 10. "          DODMBS ,Disable optimized Data Memory Barrier behavior" "No,Yes"
        bitfld.long 0x00 7. "           EXCL     ,Exclusive L1/L2 cache control" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x00 6. " SMP      ,Data requests with Inner Cacheable Shared attributes are treated as cacheable" "Disabled,Enabled"
        bitfld.long 0x00 0. "     FW     ,FW" "Low,High"
group.long c15:0x201++0x0
    line.long 0x0 "CPACR,Coprocessor Access Control Register"
        bitfld.long 0x0 31. " ASEDIS   ,Disable Advanced SIMD Extension functionality" "No,Yes"
        bitfld.long 0x0 30. "          D32DIS ,Disable use of D16-D31 of the VFP register file" "No,Yes"
        bitfld.long 0x0 22.--23. "           CP11     ,Coprocesor access control" "Denied,Privileged,Reserved,Full"
        textline "                 "
        bitfld.long 0x0 20.--21. " CP10     ,Coprocesor access control" "Denied,Privileged,Reserved,Full"
    textline "                 "
    
group.long c15:0x11++0x0
    line.long 0x0 "SCR,Secure Configuration Register"
        bitfld.long 0x00 6. " nET      ,Not early termination" "Not early,Early"
        bitfld.long 0x00 5. "    AW     ,Controls whether the Non-secure world can modify the A-bit in the CPSR" "Not allowed,Allowed"
        bitfld.long 0x00 4. "   FW       ,FW-bit controls whether the Non-secure world can modify the F-bit in the CPSR" "Not allowed,Allowed"
        textline "                 "
        bitfld.long 0x00 3. " EA       ,External Abort  exceptions handled in Abort mode or Monitor mode" "Abort,Monitor"
        bitfld.long 0x00 2. "      FIQ    ,FIQ exceptions handled in Abort mode or Monitor mode" "FIQ,Monitor"
        bitfld.long 0x00 1. "       IRQ      ,IRQ exceptions handled in Abort mode or Monitor mode" "IRQ,Monitor"
        textline "                 "
        bitfld.long 0x00 0. " NS       ,Secure mode " "Secure,Non-secure"
group.long c15:0x111++0x0
    line.long 0x0 "SDER,Secure Debug Enable Register"
        bitfld.long 0x00 1. " SUNIDEN  ,Non-Invasive Secure User Debug Enable bit" "Denied,Permitted"
        bitfld.long 0x00 0. "    SUIDEN ,Invasive Secure User Debug Enable bit" "Denied,Permitted"            
group.long c15:0x0211++0x00
    line.long 0x00 "NSACR,Non-Secure Access Control Register"
        bitfld.long 0x00 18. " NS_SMP   ,Determines if the SMP bit of the Auxiliary Control Register is writable in Non-secure state" "Disabled,Enabled"
        bitfld.long 0x00 17. "     TL     ,Lockable Page Table Entries Allocation in Nonsecure World" "Denied,Permitted"
        bitfld.long 0x00 15. "     NSASEDIS ,Disable Non-secure Advanced SIMD Extension functionality" "Denied,Permitted"
        textline "                 "
        bitfld.long 0x00 14. " NSD32DIS ,Disable the Non-secure use of D16-D31 of the VFP register" "Denied,Permitted"
          bitfld.long 0x00 11. "    CP11   ,Coprocessor 11 in the Nonsecure World Access Permission" "Denied,Permitted"
        bitfld.long 0x00 10. "     CP10     ,Coprocessor 10 in the Nonsecure World Access Permission" "Denied,Permitted"
group.long c15:0x0311++0x00
    line.long 0x00 "VCR,Virtualization Control Register"
        bitfld.long 0x00 8. " AMO      ,Abort Mask Override" "0,1"
        bitfld.long 0x00 7. "            IMO    ,IRQ Mask Override" "0,1"
        bitfld.long 0x00 6. "             IFO      ,FIQ Mask Override" "0,1"
    textline "                 "
    
group.long c15:0x000c++0x00
    line.long 0x00 "VBAR,Secure or Nonsecure Vector Base Address Register"
        hexmask.long 0x00 5.--31. 0x20 " VBA      ,Base Address"
group.long c15:0x10c++0x00
    line.long 0x0 "MVBAR,Monitor Vector Base Address Register"
        hexmask.long 0x00 5.--31. 0x20 " MVBA     , Monitor Vector Base Address"
rgroup.long c15:0x1C++0x0
    line.long 0x0 "ISR,Interrupt status Register"
        bitfld.long 0x0 8. " A        ,Pending External Abort" "Not pending,Pending"
        bitfld.long 0x0 7. "  I      ,Pending IRQ" "Not pending,Pending"
        bitfld.long 0x0 6. "   F        ,Pending FIQ" "Not pending,Pending"
group.long c15:0x11c++0x0
    line.long 0x00 "VIR,Virtualization Interrupt Register"
        bitfld.long 0x00 8. " VA       ,Virtual Abort" "0,1"
        bitfld.long 0x00 7. "            VI     ,Virtual IRQ" "0,1"
        bitfld.long 0x00 6. "             VF       ,Virtual FIQ" "0,1"

group.long c15:0x400f++0x0
    line.long 0x00 "CBAR,Configuration Base Address Register"
        hexmask.long 0x00 0.--31. 1. " CBA      ,Configuration Base Address"

tree.end

width 0x08
tree "Memory Management Unit"
group.long c15:0x1++0x0
    line.long 0x0 "SCTLR,Control Register"
        bitfld.long 0x0 30. " TE      ,Thumb exception enable" "ARM,Thumb"
        bitfld.long 0x0 29. "        AFE     ,Access Flag Enable" "Disabled,Enabled"
        bitfld.long 0x0 28. "     TRE      ,TEX remap enable" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x0 27. " NMFI    ,DNonmaskable Fast Interrupt enable" "Disabled,Enabled"
        bitfld.long 0x0 25. "     EE      ,Exception endianess" "Little,Big"
        bitfld.long 0x0 14. "       RR       ,Replacement strategy for caches, BTAC, and micro TLBs" "Random,Round robin"
        textline "                 "
        bitfld.long 0x0 13. " V       ,Base Location of Exception Registers" "0x00000000,0xFFFF0000"
        bitfld.long 0x0 12. "   I       ,Instruction Cache Enable" "Disabled,Enabled"
        bitfld.long 0x0 11. "     Z        ,Branch Prediction Enable" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x0 10. " SW      ,SWP/SWPB Enable" "Disabled,Enabled"
        bitfld.long 0x0 2. "     C       ,Enable unified cache or data cache" "Disabled,Enabled"
        bitfld.long 0x0 1. "     A        ,Strict Alignment" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x0 0. " M       ,MMU or Protection Unit" "Disabled,Enabled"      
    textline " "
    
group.long c15:0x0002++0x00
    line.long 0x00 "TTBR0,Translation Table Base Register 0"
        hexmask.long 0x00 14.--31. 0x4000 " TTB0    ,Translation Table Base Address"
        bitfld.long 0x00 6. 0. "                IRGN[1:0] ,Indicates inner cacheability" "Noncacheable,Back/allocated,Through,Back/not allocated"
        textline "                 "
        bitfld.long 0x00 3.--4. " RGN     ,Outer Cacheable Attributes for Page Table Walking" "Noncacheable,Back/allocated,Through,Back/not allocated"
        bitfld.long 0x00 1. "      S         ,Page Table Walk to Shared Memory" "Nonshared,Shared"
group.long c15:0x0102++0x00
    line.long 0x00 "TTBR1,Translation Table Base Register 1"
        hexmask.long 0x00 14.--31. 0x4000 " TTB1    ,Translation Table Base Address"
        bitfld.long 0x00 6. 0. "                IRGN[1:0] ,Indicates inner cacheability" "Noncacheable,Back/allocated,Through,Back/not allocated"
        textline "                 "
        bitfld.long 0x00 3.--4. " RGN     ,Outer Cacheable Attributes for Page Table Walking" "Noncacheable,Back/allocated,Through,Back/not allocated"
        bitfld.long 0x00 1. "      S         ,Page Table Walk to Shared Memory" "Nonshared,Shared"
group.long c15:0x0202++0x00
    line.long 0x00 "TTBCR,Translation Table Base Control Register"
         bitfld.long 0x00 5. " PD1     ,Page Table Walk on a TLB Miss When Using Translation Table Base Register 1" "Enable,Disable"
         bitfld.long 0x00 4. "  PD0  ,Page Table Walk on a TLB Miss When Using Translation Table Base Register 0" "Enable,Disable"
         bitfld.long 0x0 0.--2. "   N    ,Translation Table Base Register 0 page table boundary size" "Off,0x80000000,0x40000000,0x20000000,0x10000000,0x08000000,0x04000000,0x02000000"
    textline " "
    
group.long c15:0x3--0x3 
 line.long 0x0 "DACR,Domain Access Control Register"
  bitfld.long 0x0 30.--31. " D15  ,Domain Access 15" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 28.--29. "  D14 ,Domain Access 14" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 26.--27. "  D13 ,Domain Access 13" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 24.--25. "  D12 ,Domain Access 12" "Denied,Client,Reserved,Manager"
 textline "                 "
  bitfld.long 0x0 22.--23. " D11  ,Domain Access 11" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 20.--21. "  D10 ,Domain Access 10" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 18.--19. "  D9  ,Domain Access 9" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 16.--17. "  D8  ,Domain Access 8" "Denied,Client,Reserved,Manager"
 textline "                 "
  bitfld.long 0x0 14.--15. " D7   ,Domain Access 7" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 12.--13. "  D6  ,Domain Access 6" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 10.--11. "  D5  ,Domain Access 5" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 8.--9. "  D4  ,Domain Access 4" "Denied,Client,Reserved,Manager"
 textline "                 "
  bitfld.long 0x0 6.--7. " D3   ,Domain Access 3" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 4.--5. "  D2  ,Domain Access 2" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 2.--3. "  D1  ,Domain Access 1" "Denied,Client,Reserved,Manager"
  bitfld.long 0x0 0.--1. "  D0  ,Domain Access 0" "Denied,Client,Reserved,Manager"
    textline " "
    
group.long c15:0x0005++0x00
    line.long 0x00 "DFSR,Data Fault Status Register"
        bitfld.long 0x00 12. " EXT     ,External Abort Qualifier" "DECERR,SLVERR"
        bitfld.long 0x00 11. "                  RW        ,Access Caused an Abort Type" "Read,Write"
        textline "                 "
        bitfld.long 0x00 4.--7. " DOMAIN  ,Domain Accessed When a Data Fault Occurs" "D0,D1,D2,D3,D4,D5,D6,D7,D8,D9,D10,D11,D12,D13,D14,D15"
        bitfld.long 0x00 0.--3. 10.  "                     STATUS    ,Generated Exception Type" "Reserved,Alignment,Debug,Access/section,Instruction,Translation/section,Access/page,Translation/page,Nontranslation/synchronous external,Domain/section,Reserved,Domain/page,L1/external,Permission/section,L2/external,Permission/page,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Asynchronous external,?..."
group.long c15:0x0006++0x00
    line.long 0x00 "DFAR,Data Fault Address Register"
        hexmask.long 0x00 0.--31. 1. " DFA     ,Data Fault Address"
group.long c15:0x0105++0x00
    line.long 0x00 "IFSR,Instruction Fault Status Register"
        bitfld.long 0x00 12. " SD      ,External Abort Qualifier" "DECERR,SLVERR"
        bitfld.long 0x00 0.--3. 10. "                  STATUS    ,Generated Exception Type" "Reserved,Alignment,Debug,Access/section,Instruction,Translation/section,Access/page,Translation/page,Nontranslation/synchronous external,Domain/section,Reserved,Domain/page,L1/external,Permission/section,L2/external,Permission/page,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Asynchronous external,?..."
group.long c15:0x0206++0x00
    line.long 0x00 "IFAR,Instruction Fault Address Register"
        hexmask.long 0x00 0.--31. 1. " IFA     ,Instruction Fault Address"
group.long c15:0x0015++0x00
    line.long 0x00 "DAFSR,Data Auxiliary Fault Status Register"
        hexmask.long 0x00 0.--31. 1. " DAFS    ,Data Auxiliary Fault Status"
group.long c15:0x0115++0x00
    line.long 0x00 "IAFSR,Instruction Auxiliary Fault Status Register"
        hexmask.long 0x00 0.--31. 1. " IAFS    ,Instruction Auxiliary Fault Status"    
    textline " "
    
group.long c15:0x0047++0x00
    line.long 0x00 "PAR,PA Register"
        hexmask.long 0x00 12.--31. 0x1000 " PA      ,Physical Adress"
        bitfld.long 0x00 9. "                NS        ,Non-secure" "Not secured,Secured"
        textline "                 "
        bitfld.long 0x00 7. " SH      ,Shareable attribute" "Non-shareable,Shareable"
        bitfld.long 0x00 4.--6. "           Inner     ,Signals region inner attributes" "Noncacheable,Strongly-ordered,Reserved,Device,Reserved,Write-back allocate,Write-through,Write-back"
        textline "                 "
        bitfld.long 0x00 2.--3. " Outer   ,Signals region outer attributes for normal memory type" "Noncacheable,Write-back allocate,Write-through,Write-back"
        bitfld.long 0x00 1. "     SS        ,Supersection Enable bit" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x00 0. " F       ,Translation Successful" "Successful,No successful"
        textline " "

group.long c15:0x002A++0x0
    line.long 0x00 "PRRR,Primary Region Remap Register"
        bitfld.long 0x00 19. " NS1     ,Shareable Attribute Remap when S=1 for Normal Regions" "Remapped,Not remapped"
        bitfld.long 0x00 18. "            NS0       ,Shareable Attribute Remap when S=0 for Normal Regions" "Not remapped,Remapped"
        textline "                 "
        bitfld.long 0x00 17. " DS1     ,Shareable Attribute Remap when S=1 for Device regions" "Remapped,Not remapped"
        bitfld.long 0x00 16. "            DS0       ,Shareable Attribute Remap when S=0 for Device regions" "Not remapped,Remapped"
        textline "                 "
        bitfld.long 0x00 14.--15. " TR7     ,{TEX[0] C B} = b111 Remap" "Strongly ordered,Device,Normal,UNP"
        bitfld.long 0x00 12.--13. "        TR6       ,{TEX[0] C B} = b110 Remap" "Strongly ordered,Device,Normal,UNP"
        textline "                 "
        bitfld.long 0x00 10.--11. " TR5     ,{TEX[0] C B} = b101 Remap" "Strongly ordered,Device,Normal,UNP"
        bitfld.long 0x00 8.--9. "        TR4       ,{TEX[0] C B} = b100 Remap" "Strongly ordered,Device,Normal,UNP"
        textline "                 "
        bitfld.long 0x00 6.--7. " TR3     ,{TEX[0] C B} = b011 Remap" "Strongly ordered,Device,Normal,UNP"
        bitfld.long 0x00 4.--5. "        TR2       ,{TEX[0] C B} = b010 Remap" "Strongly ordered,Device,Normal,UNP"
        textline "                 "
        bitfld.long 0x00 2.--3. " TR1     ,{TEX[0] C B} = b001 Remap" "Strongly ordered,Device,Normal,UNP"
        bitfld.long 0x00 0.--1. "        TR0       ,{TEX[0] C B} = b000 Remap" "Strongly ordered,Device,Normal,UNP"
group.long c15:0x012A++0x0
    line.long 0x00 "NMRR,Normal Memory Remap Register"
        bitfld.long 0x00 30.--31. " OR7     ,Outer Attribute for {TEX[0] C B} = b111 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        bitfld.long 0x00 28.--29. "  OR6       ,Outer Attribute for {TEX[0] C B} = b110 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        textline "                 "
        bitfld.long 0x00 26.--27. " OR5     ,Outer Attribute for {TEX[0] C B} = b101 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        bitfld.long 0x00 24.--25. "  OR4       ,Outer Attribute for {TEX[0] C B} = b100 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        textline "                 "
        bitfld.long 0x00 22.--23. " OR3     ,Outer Attribute for {TEX[0] C B} = b011 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        bitfld.long 0x00 20.--21. "  OR2       ,Outer Attribute for {TEX[0] C B} = b010 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        textline "                 "
        bitfld.long 0x00 18.--19. " OR1     ,Outer Attribute for {TEX[0] C B} = b001 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        bitfld.long 0x00 16.--17. "  OR0       ,Outer Attribute for {TEX[0] C B} = b000 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        textline "                 "
        bitfld.long 0x00 14.--15. " IR7     ,Inner attribute for {TEX[0] C B} = b111 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        bitfld.long 0x00 12.--13. "  IR6       ,Inner attribute for {TEX[0] C B} = b110 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        textline "                 "
        bitfld.long 0x00 10.--11. " IR5     ,Inner attribute for {TEX[0] C B} = b101 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        bitfld.long 0x00 8.--9. "  IR4       ,Inner attribute for {TEX[0] C B} = b100 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        textline "                 "
        bitfld.long 0x00 6.--7. " IR3     ,Inner attribute for {TEX[0] C B} = b011 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        bitfld.long 0x00 4.--5. "  IR2       ,Inner attribute for {TEX[0] C B} = b010 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        textline "                 "
        bitfld.long 0x00 2.--3. " IR1     ,Inner attribute for {TEX[0] C B} = b001 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
        bitfld.long 0x00 0.--1. "  IR0       ,Inner attribute for {TEX[0] C B} = b000 Remap" "Noncachable,Write-back allocate,Write-through,Write-back no allocate"
    textline " "



group.long c15:0x500f++0x0
    line.long 0x00 "TLBHR,TLB Hitmap Register"
        bitfld.long 0x00 3. " 16MB ,16MB supersections are present in the TLB" "no,yes"
        bitfld.long 0x00 2. " 1MB ,1MB sections are present in the TLB" "no,yes"
        bitfld.long 0x00 1. " 16kB ,16kB pages are present in the TLB" "no,yes"
        bitfld.long 0x00 0. " 4kB ,4kB pages are present in the TLB" "no,yes"
    textline " "

group.long c15:0x10d++0x0
    line.long 0x0 "CONTEXT,Context ID Register"
        hexmask.long.tbyte 0x0 8.--31. 1. " PROCID  ,Process ID"
        hexmask.long.byte 0x0 0.--7. 1. "                  ASID      ,Application Space ID"
group.long c15:0x020d++0x00
    line.long 0x00 "URWTPID,User Read/Write Thread and Process ID Register"
        hexmask.long 0x00 0.--31. 1. " URWTPID ,User Read/Write Thread and Process ID"
group.long c15:0x030d++0x00
    line.long 0x00 "UROTPID,User Read-Only Thread and Process ID Register"
        hexmask.long 0x00 0.--31. 1. " UROTPID ,User Read-Only Thread and Process ID"
group.long c15:0x040d++0x00
    line.long 0x00 "POTPID,Privileged Only Thread and Process ID Register"
        hexmask.long 0x00 0.--31. 1. " POTPID  ,Privileged Only Thread and Process ID"
tree.end

width 0x8
tree "Cache Control and Configuration"
rgroup.long c15:0x1100++0x0
    line.long 0x0 "CLIDR,Cache Level ID Register"
        bitfld.long 0x00 27.--29. " LOU     ,Level of Unification" "Level 1,Level 2,Level 3,Level 4,Level 5,Level 6,Level 7,Level 8"
        bitfld.long 0x00 24.--26. "                    LOC    ,Level of Coherency" "Level 1,Level 2,Level 3,Level 4,Level 5,Level 6,Level 7,Level 8"
        textline "                 "
        bitfld.long 0x00 21.--23. " CType8  ,Cache type for levels 8" "No cache,I-cache,D-cache,Separate I/D,Unified,?..."
        bitfld.long 0x00 18.--20. "               CType7 ,Cache type for levels 7" "No cache,I-cache,D-cache,Separate I/D,Unified,?..."
        textline "                 "
        bitfld.long 0x00 15.--17. " CType6  ,Cache type for levels 6" "No cache,I-cache,D-cache,Separate I/D,Unified,?..."
        bitfld.long 0x00 12.--14. "               CType5 ,Cache type for levels 5" "No cache,I-cache,D-cache,Separate I/D,Unified,?..."
        textline "                 "
        bitfld.long 0x00 9.--11. " CType4  ,Cache type for levels 4" "No cache,I-cache,D-cache,Separate I/D,Unified,?..."
        bitfld.long 0x00 6.--8. "               CType3 ,Cache type for levels 3" "No cache,I-cache,D-cache,Separate I/D,Unified,?..."
        textline "                 "
        bitfld.long 0x00 3.--5. " CType2  ,Cache type for levels 2" "No cache,I-cache,D-cache,Separate I/D,Unified,?..."
        bitfld.long 0x00 0.--2. "               CType1 ,Cache type for levels 1" "No cache,I-cache,D-cache,Separate I/D,Unified,?..."
rgroup.long c15:0x1700++0x0
    line.long 0x0 "AIDR,Auxiliary ID Register"
        hexmask.long 0x00 0.--31. 1. " AID     ,Auxiliary ID"
rgroup.long c15:0x1000++0x0
    line.long 0x0 "CCSIDR,Current Cache Size ID Register"
         bitfld.long 0x00 31. " WT      ,Write-Through" "Not Supported,Supported"
        bitfld.long 0x00 30. "              WB     ,Write-Back" "Not Supported,Supported"
        textline "                 "
        bitfld.long 0x00 29. " RA      ,Read-Allocate" "Not Supported,Supported"
        bitfld.long 0x00 28. "              WA     ,Write-Allocate" "Not Supported,Supported"
        textline "                 "
        hexmask.long.word 0x00 13.--27. 1.  " SETS    ,Number of Sets"
        hexmask.long.word 0x00 3.--12. 1.  "                       ASSOC  ,Associativity"
        textline "                 "
        bitfld.long 0x00 0.--2. " LSIZE   ,Line Size" "4 words,8 words,16 words,32 words,64 words,128 words,256 words,512 words"
group.long c15:0x2000++0x0
    line.long 0x0 "CSSELR,Cache Size Selection Register"
        bitfld.long 0x00 1.--3. " LEVEL   ,Level" "Level 1,Level 2,Level 3,Level 4,Level 5,Level 6,Level 7,Level 8"
        bitfld.long 0x00 0. "                    IND    ,Instruction/Not Data" "Data,Instruction"
tree.end

width 0x8

tree "L2 Preload Engine"
    rgroup c15:0x000b++0x00
        line.long 0x00 "PLEIDR,PLE Identification Register 0"
            bitfld.long 0x00 0. " CH0P ,Channel 0 Present" "Not present,Present"
    rgroup c15:0x020b++0x00
        line.long 0x00 "PLESR,PLE Status Register"
            bitfld.long 0x00 0. " CH0R ,Channel 0 Run" "Not running,Running"
    rgroup c15:0x040b++0x00
        line.long 0x00 "PLEFSR,PLE FIFO Status Register"
    group c15:0x001b++0x00
        line.long 0x00 "PLEUAR,PLE User Accessibility Register"
            bitfld.long 0x00 0. " U0  ,User Mode Process Access Registers for Channel 0 Permission" "Not permitted,Permitted"
    group c15:0x011b++0x00
        line.long 0x00 "PLEPCR,PLE Parameters Control Register"
tree.end

width 12.
tree "System Performance Monitor"
group.long c15:0xC9++0x0
    line.long 0x0 "PMCR,Performance Monitor Control Register"
        hexmask.long.byte 0x00 24.--31. 1. " IMP  ,Implementer code"
        hexmask.long.byte 0x00 16.--23. 1. "           IDCODE ,Identification code"
        bitfld.long 0x00 11.--15. "           N  ,Number of counters implemented" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 5. "           DP ,Disable CCNT when prohibited" "Enabled,Disabled"
        textline "                     "
        bitfld.long 0x00 4. " X    ,Export Enabled" "Disabled,Enabled"
        bitfld.long 0x00 3. "     D      ,Clock Divider" "Every cycle,64th cycle"
        bitfld.long 0x00 2. "  C  ,Clock Counter Reset" "No action,Reset"
        bitfld.long 0x00 1. "    P  ,Performance Counter Reset" "No action,Reset"
        textline "                     "
        bitfld.long 0x00 0. " E    ,Counters Enable" "Disabled,Enabled"
group.long c15:0x1C9++0x0
    line.long 0x0 "PMCNTENSET,Count Enable Set Register"
        bitfld.long 0x00 31. " C    ,CCNT Enabled" "Disabled,Enabled"
        bitfld.long 0x00  5. "     P5     ,PMN5 Enabled" "Disabled,Enabled"
        bitfld.long 0x00  4. "     P4 ,PMN5 Enabled" "Disabled,Enabled"
        bitfld.long 0x00  3. "     P3 ,PMN3 Enabled" "Disabled,Enabled"
        textline "                     "
        bitfld.long 0x00  2. " P2   ,PMN2 Enabled" "Disabled,Enabled"
        bitfld.long 0x00  1. "     P1     ,PMN1 Enabled" "Disabled,Enabled"
        bitfld.long 0x00  0. "     P0 ,PMN0 Enabled" "Disabled,Enabled"
group.long c15:0x2C9++0x0
    line.long 0x0 "PMCNTENCLR,Count Enable Clear Register"
        bitfld.long 0x00 31. " C    ,CCNT Enabled" "Disabled,Enabled"
        bitfld.long 0x00  5. "     P5     ,PMN5 Enabled" "Disabled,Enabled"
        bitfld.long 0x00  4. "     P4 ,PMN5 Enabled" "Disabled,Enabled"
        bitfld.long 0x00  3. "     P3 ,PMN3 Enabled" "Disabled,Enabled"
        textline "                     "
        bitfld.long 0x00  2. " P2   ,PMN2 Enabled" "Disabled,Enabled"
        bitfld.long 0x00  1. "     P1     ,PMN1 Enabled" "Disabled,Enabled"
        bitfld.long 0x00  0. "     P0 ,PMN0 Enabled" "Disabled,Enabled"
group.long c15:0x3C9++0x0
    line.long 0x0 "PMOVSR,Overflow Flag Status Register"
        eventfld.long 0x00 31. " C    ,CCNT overflowed" "No overflow,Overflow"
        eventfld.long 0x00  5. "  P5     ,PMN5 overflow" "No overflow,Overflow"
        eventfld.long 0x00  4. "  P4 ,PMN5 overflow" "No overflow,Overflow"
        eventfld.long 0x00  3. "  P3 ,PMN3 overflow" "No overflow,Overflow"
        textline "                     "
        eventfld.long 0x00  2. " P2   ,PMN2 overflow" "No overflow,Overflow"
        eventfld.long 0x00  1. "  P1     ,PMN1 overflow" "No overflow,Overflow"
        eventfld.long 0x00  0. "  P0 ,PMN0 overflow" "No overflow,Overflow"
wgroup.long c15:0x4C9++0x0
    line.long 0x0 "PMSWINC,Software Increment Register"
        eventfld.long 0x00  5. " P5   ,Increment  PMN2" "No action,Increment"
        eventfld.long 0x00  4. "    P4     ,Increment  PMN1" "No action,Increment"
        eventfld.long 0x00  3. "    P3 ,Increment  PMN3" "No action,Increment"
        eventfld.long 0x00  2. "    P2 ,Increment  PMN2" "No action,Increment"
        textline "                     "
        eventfld.long 0x00  1. " P1   ,Increment  PMN1" "No action,Increment"
        eventfld.long 0x00  0. "    P0     ,Increment  PMN0" "No action,Increment"
group.long c15:0x5C9++0x0
    line.long 0x0 "PMSELR,Performance Counter Selection Register"
        bitfld.long 0x00 0.--5. " SEL  ,Selection value" "CNT0,CNT1,CNT2,CNT3,CNT4,CNT5,?..."
group.long c15:0xD9++0x0
    line.long 0x00 "PMCCNTR,Cycle Count Register"
        hexmask.long 0x00 0.--31. 1. " CCNT ,Cycle Count"
group.long c15:0x01d9++0x00
    line.long 0x00 "PMXEVTYPER,Event Selection Register"
        hexmask.long.byte 0x00 0.--7. 1. " SEL  ,Event Selection"
group.long c15:0x02d9++0x00
    line.long 0x00 "PMCNT,Performance Monitor Count Register"
        hexmask.long 0x00 0.--31. 1. " PMC  ,Performance Monitor Count"
group.long c15:0xE9++0x0
    line.long 0x0 "PMUSERENR,User Enable Register"
        bitfld.long 0x00  0. " EN   ,User Mode Enable" "Disabled,Enabled"
group.long c15:0x1E9++0x0
    line.long 0x0 "PMINTENSET,Interrupt Enable Set Register"
        bitfld.long 0x00 31. " C    ,CCNT Overflow Interrupt Enable" "Disabled,Enabled"
        bitfld.long 0x00  5. "     P5     ,PMCNT5 Overflow Interrupt Enable" "Disabled,Enabled"
        bitfld.long 0x00  4. "     P4 ,PMCNT4 Overflow Interrupt Enable" "Disabled,Enabled"
        bitfld.long 0x00  3. "     P3 ,PMCNT3 Overflow Interrupt Enable" "Disabled,Enabled"
        textline "                     "
        bitfld.long 0x00  2. " P2   ,PMCNT2 Overflow Interrupt Enable" "Disabled,Enabled"
        bitfld.long 0x00  1. "     P1     ,PMCNT1 Overflow Interrupt Enable" "Disabled,Enabled"
        bitfld.long 0x00  0. "     P0 ,PMCNT0 Overflow Interrupt Enable" "Disabled,Enabled"
group.long c15:0x2E9++0x0
    line.long 0x0 "PMINTENCLR,Interrupt Enable Clear Register"
        eventfld.long 0x00 31. " C    ,CCNT Overflow Interrupt Enable" "Disabled,Enabled"
        eventfld.long 0x00  5. "     P5     ,PMCNT5 Overflow Interrupt Enable" "Disabled,Enabled"
        eventfld.long 0x00  4. "     P4 ,PMCNT4 Overflow Interrupt Enable" "Disabled,Enabled"
        eventfld.long 0x00  3. "     P3 ,PMCNT3 Overflow Interrupt Enable" "Disabled,Enabled"
        textline "                     "
        eventfld.long 0x00  2. " P2   ,PMCNT2 Overflow Interrupt Enable" "Disabled,Enabled"
        eventfld.long 0x00  1. "     P1     ,PMCNT1 Overflow Interrupt Enable" "Disabled,Enabled"
        eventfld.long 0x00  0. "     P0 ,PMCNT0 Overflow Interrupt Enable" "Disabled,Enabled"
tree.end
width 0xb


tree "Debug Registers"

width 10.

rgroup c14:0x000--0x000
 line.long 0x0 "DBGDIDR,Debug ID Register"
  bitfld.long 0x0 28.--31. " WRP      ,Number of Watchpoint Register Pairs" "1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16"
  bitfld.long 0x0 24.--27. "               BRP      ,Number of Breakpoint Register Pairs" "1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16"
  bitfld.long 0x0 20.--23. "               Context ,Number of BRPs with Context ID Comparison Capability" "1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16"
 textline "                   "
  bitfld.long 0x0 16.--19. " Version  ,Debug Architecture Version" "Reserved,ARMv6,ARMv6.1,ARMv7,?..."
 textline "                   "
  bitfld.long 0x0 13. " PCSAMPLE ,PC Sample register implemented" "Not implemented,Implemented"
  bitfld.long 0x0 12. "  Security ,Security Extensions implemented" "Not implemented,Implemented"
 textline "                   "
  bitfld.long 0x0 4.--7. " Variant  ,Implementation-defined Variant Number" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0x0 0.--3. "               Revision ,Implementation-defined Revision Number" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

width 10.
group c14:0x22--0x22
 line.long 0x0 "DBGDSCR,Debug Status and Control Register"
  bitfld.long 0x0 30. " DTRRXfull   ,The DTRRX Full Flag" "Empty,Full"
  bitfld.long 0x0 29. "                 DTRTXfull   ,The DTRTX Full Flag" "Empty,Full"
 textline "                   "
    bitfld.long 0x00 27. " DTRRXfull_l ,The DTRRX Full Flag 1" "Empty,Full"
    bitfld.long 0x00 26. "                 DTRTXfull_l ,The DTRTX Full Flag 1" "Empty,Full"
 textline "                   "
  bitfld.long 0x0 25. " SPA         ,Sticky Pipeline Advance" "No effect,Instruction retired"
  bitfld.long 0x0 24. "   IC          ,Instruction Complete" "Executing,Not executing"
 textline "                   "
  bitfld.long 0x0 20.--21. " DTR         ,DTR Access Mode" "Non-blocking,Stall,Fast,?..."
  bitfld.long 0x0 19. "          NSWS        ,Imprecise Data Aborts discarded" "Not discarded,Discarded"
 textline "                   "
 bitfld.long 0x0 18. " NS          ,Non-secure World Status" "Secured,Not secured"
  bitfld.long 0x0 17. "           nSPNIDEN    ,Secure Non-invasive Debug Disabled" "Enabled,Disabled"
 textline "                   "
  bitfld.long 0x0 16. " nSPIDEN     ,Secure Invasive Debug Disabled" "Enabled,Disabled"
  bitfld.long 0x0 15. "              MONITOR     ,Monitor Debug-mode enable" "Disabled,Enabled"
   textline "                   "
  bitfld.long 0x0 14. " HDEn        ,Halting Debug-mode enable" "Disabled,Enabled"
  bitfld.long 0x0 13. "              EXECUTE     ,Execute instruction enable" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 12. " COMMS       ,User mode access to Comms Channel disable" "Enabled,Disabled"
  bitfld.long 0x0 11. "              IntDis      ,Disable Interrupts" "Enabled,Disabled"
 textline "                   "
  bitfld.long 0x0 10. " DbgAck      ,Force Debug Acknowledge" "Not forced,Forced"
  bitfld.long 0x0 8. "            uExt        ,Sticky Undefined Exception" "No exception,Exception"
 textline "                   "
  bitfld.long 0x0 7. " IABORT      ,Sticky Imprecise Abort" "Not aborted,Aborted"
  bitfld.long 0x0 6. "           PABORT      ,Sticky Precise Abort" "Not aborted,Aborted"
 textline "                   "
  bitfld.long 0x0 2.--5. " MOE         ,Method of Debug Entry" "Debug Entry,Breakpoint,Imprecise Watchpoint,BKPT instruction,External debug,Vector catch,Reserved,Reserved,OS Unlock,?..."
  bitfld.long 0x0 1. "  RESTARTED   ,Core Restarted" "Debug not exited,Debug exited"
 textline "                   "
  bitfld.long 0x0 0. " HALTED      ,Core Halted" "Normal state,Debug state"
width 10.
if (((data.long(c14:0x00))&0x01000)==0x00000)
group c14:0x007--0x007
 line.long 0x0 "DBGVCR,Vector Catch Register"
  bitfld.long 0x0 7. " FIQ     ,Vector Catch Enable FIQ" "Disabled,Enabled"
  bitfld.long 0x0 6. "  IRQ     ,Vector Catch Enable IRQ" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 4. " DABORT  ,Vector Catch Enable Data Abort" "Disabled,Enabled"
  bitfld.long 0x0 3. "  PABORT  ,Vector Catch Enable Prefetch Abort" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 2. " SWI     ,Vector Catch Enable SWI" "Disabled,Enabled"
  bitfld.long 0x0 1. "  UNDEF   ,Vector Catch Enable Undefined Instruction" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 0. " RESET   ,Vector Catch Enable Reset" "Disabled,Enabled"
else
group c14:0x007--0x007
 line.long 0x0 "DBGVCR,Vector Catch Register"
  bitfld.long 0x0 31. " FIQN    ,Vector Catch Enable FIQ (Non-secure)" "Disabled,Enabled"
  bitfld.long 0x0 30. "  IRQN    ,Vector Catch Enable IRQ (Non-secure)" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 28. " DABORTN ,Vector Catch Enable Data Abort (Non-secure)" "Disabled,Enabled"
  bitfld.long 0x0 27. "  PABORTN ,Vector Catch Enable Prefetch abort (Non-secure)" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 26. " SWIN    ,Vector Catch Enable SWI (Non-secure)" "Disabled,Enabled"
  bitfld.long 0x0 25. "  UNDEFS  ,Vector Catch Enable Undefined (Non-secure)" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 15. " FIQS    ,Vector Catch Enable FIQ (Secure)" "Disabled,Enabled"
  bitfld.long 0x0 14. "  IRQS    ,Vector Catch Enable IRQ (Secure)" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 12. " DABORTS ,Vector Catch Enable Data Abort (Secure)" "Disabled,Enabled"
    bitfld.long 0x00 11. "  PABORTS ,Vector Catch Enable Prefetch abort (Secure)" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 10. " SMI     ,Vector Catch Enable SMI (Secure)" "Disabled,Enabled"
  bitfld.long 0x0 7. "  FIQ     ,Vector Catch Enable FIQ" "Disabled,Enabled"
  textline "                   "
  bitfld.long 0x0 6. " IRQ     ,Vector Catch Enable IRQ" "Disabled,Enabled"
  bitfld.long 0x0 4. "  DABORT0 ,Vector Catch Enable Data Abort" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 3. " PABORT  ,Vector Catch Enable Prefetch Abort" "Disabled,Enabled"
  bitfld.long 0x0 2. "  SWI     ,Vector Catch Enable SWI" "Disabled,Enabled"
 textline "                   "
  bitfld.long 0x0 1. " UNDEF   ,Vector Catch Enable Undefined Instruction" "Disabled,Enabled"
  bitfld.long 0x0 0. "  RESET   ,Vector Catch Enable Reset" "Disabled,Enabled"
endif

width 10.
hgroup c14:0x020--0x020
    hide.long 0x0 "DBGDTRRX,Target -> Host Data Transfer Register"
        in
group c14:0x023--0x023
    line.long 0x0 "DBGDTRTX,Host -> Target Data Transfer Register"
    hexmask.long 0x00 0.--31. 1. " HTD   ,Host -> target data"
group c14:0x09++0x00
    line.long 0x00 "DBGECR,Event Catch Register"
        bitfld.long 0x00 0. " OSUC  ,OS Unlock Catch" "Disabled,Enabled"
group c14:0x0a++0x00
    line.long 0x00 "DBGDSCCR,Debug State Cache Control Register"
        bitfld.long 0x00 2. " NWT   ,Not Write-Through" "Forced,Normal"
        bitfld.long 0x00 0. "         DUCL        ,Data and Unified Cache Linefill" "Disabled,Normal"
wgroup c14:0x21++0x00
    line.long 0x00 "DBGITR,Instruction Transfer Register"
        hexmask.long 0x00 0.--31. 1. " Data  ,ARM Instruction for the Processor in Debug State Execute"
wgroup c14:0x24++0x00
    line.long 0x00 "DBGDRCR,Debug Run Control Register"
        bitfld.long 0x00 3. " CSPA  ,Clear Sticky Pipeline Advance" "Not cleared,Cleared"
        bitfld.long 0x00 2. "    CSE         ,Clear Sticky Exceptions" "Not cleared,Cleared"
         textline "                   "
        bitfld.long 0x00 1. " RR    ,Restart Request" "Not requested,Requested"
        bitfld.long 0x00 0. "  HR          ,Halt Request" "Not requested,Requested"
wgroup c14:0xc0++0x00
    line.long 0x00 "DBGOSLAR,Operating System Lock Access Register"
        hexmask.long 0x00 0.--31. 1. " OSLA  ,OS Lock Access"
rgroup c14:0xc1++0x00
    line.long 0x00 "DBGOSLSR,Operating System Lock Status Register"
        bitfld.long 0x00 2. " 32_BA ,32-Bit Access" "Not required,Required"
        bitfld.long 0x00 1. "   LB          ,Locked Bit" "Not locked,Locked"
        bitfld.long 0x00 0. "     LIB ,Lock Implemented Bit" "Not implemented,Implemented"
group c14:0xc2++0x00
    line.long 0x00 "DBGOSSRR,Operating System Save and Restore Register"
        hexmask.long 0x00 0.--31. 1. " OSSR  ,OS Save and Restore"
group c14:0xc4++0x00
    line.long 0x00 "DBGPRCR,Device Power-Down and Reset Control Register"
        bitfld.long 0x00 2. " HNDLR ,Hold non-debug logic reset" "Not held,Held"
        bitfld.long 0x00 0. "       DBGNOPWRDWN ,DBGNOPWRDWN output signal" "Low,High"
group c14:0xc5++0x00
    line.long 0x00 "DBGPRSR,Device Power-Down and Reset Status Register"
        bitfld.long 0x00 3. " SR    ,Sticky Reset Status" "Not reset,Reset"
        bitfld.long 0x00 2. "      R           ,Reset Status" "No reset,Reset"
        textline "                   "
        bitfld.long 0x00 1. " SPD   ,Sticky Power-down Status" "Not reset,Reset"
        bitfld.long 0x00 0. "      PU          ,Power-up Status" "Powered down,Powered up"
 width 11.
    tree "Processor Identifier Registers"
                rgroup c14:0x340--0x340
                 line.long 0x00 "CPUID,Main ID Register"
                      hexmask.long.byte 0x0 24.--31. 0x1 " IMPL       ,Implementer code"
                      hexmask.long.byte 0x0 20.--23. 0x1 "             SPECREV    ,Variant number"
                      textline "                    "
                      hexmask.long.byte 0x0 16.--19. 0x1 " ARCH       , Architecture"
                      hexmask.long.word 0x0 4.--15. 0x1 "             PARTNUM    ,Part Number"
                      textline "                    "
                      hexmask.long.byte 0x0 0.--3. 0x1 " REV        ,Layout Revision"
                rgroup c14:0x341--0x341
                 line.long 0x00 "CACHETYPE,Cache Type Register"
                    bitfld.long 0x0 29.--31. " FORMAT     ,Format" "Not ARMv7,Not ARMv7,Not ARMv7,Not ARMv7,ARMv7,Not ARMv7,Not ARMv7,Not ARMv7"
                    bitfld.long 0x0 24.--27. "      CWG        ,Cache Writeback Granule" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    textline "                    "
                    bitfld.long 0x0 20.--23. " ERG        ,Exclusives Reservation Granule" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    bitfld.long 0x00 16.--19. "             DMinLine   ,Words of Smallest Line Length in L1 or L2 Data Cache Number" "Reserved,Reserved,Reserved,Reserved,16x32-bit words,?..."
                    textline "                    "
                    bitfld.long 0x00 14.--15. " L1_Ipolicy ,VIPT Instruction Cache Support" "Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 0.--3. "      IMinLine   ,Words of Smallest Line Length in L1 or L2 Instruction Cache Number" "Reserved,Reserved,Reserved,Reserved,16x32-bit words,?..."
                rgroup c14:0x343--0x343
                 line.long 0x00 "TLBTYPE,TLB Type Register"
                     hexmask.long.byte 0x0 16.--23. 0x1 " ILsize     ,Specifies the number of instruction TLB lockable entries"
                     hexmask.long.byte 0x0 8.--15. 0x1 "             DLsize     ,Specifies the number of unified or data TLB lockable entries"
                      textline "                    "
                     bitfld.long 0x0 1. " TLB_size   ,TLB Size" "64,128"
                     bitfld.long 0x0 0. "            U          ,Unified or separate instruction TLBs" "Unified,Separate"
                rgroup c14:0x348--0x348
                 line.long 0x00 "ID_PFR0,Processor Feature Register 0"
                    bitfld.long 0x00 12.--15. " State3     ,Thumb-2 Execution Environment (Thumb-2EE) Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 8.--11. "      State2     ,Java Extension Interface Support" "Reserved,Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 4.--7. " State1     ,Thumb Encoding Supported by the Processor Type" "Reserved,Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 0.--3. "      State0     ,ARM Instruction Set Support" "Reserved,Supported,?..."
                rgroup c14:0x349--0x349
                 line.long 0x00 "ID_PFR1,Processor Feature Register 1"
                    bitfld.long 0x00 8.--11. " MPM        ,Microcontroller Programmer's Model Support" "Not supported,?..."
                    bitfld.long 0x00 4.--7. "  SE         ,Security Extensions Architecture v1 Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 0.--3. " PM         ,Standard ARMv4 Programmer's Model Support" "Reserved,Supported,?..."
                rgroup c14:0x34a--0x34a
                 line.long 0x00 "ID_DFR0,Debug Feature Register 0"
                    bitfld.long 0x00 20.--23. " MDM_MM     ,Microcontroller Debug Model Support" "Not supported,?..."
                    bitfld.long 0x00 16.--19. "  TDM_MM     ,Trace Debug Model (Memory-Mapped) Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 12.--15. " TDM_CB     ,Coprocessor-Based Trace Debug Model Support" "Not supported,?..."
                    bitfld.long 0x00 8.--11. "  CDM_MM     ,Memory-Mapped Debug Model Support" "Reserved,Reserved,Reserved,Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 4.--7. " SDM_CB     ,Secure Debug Model (Coprocessor) Support" "Reserved,Reserved,Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 0.--3. "      CDM_CB     ,Coprocessor Debug Model Support" "Reserved,Reserved,Reserved,Reserved,Supported,?..."
                rgroup c14:0x34b--0x34b
                 line.long 0x00 "ID_AFR0,Auxiliary Feature Register 0"
                    hexmask.long 0x00 0.--31. 1. " AF         ,Auxiliary Feature"
                rgroup c14:0x34c--0x34c
                 line.long 0x00 "ID_MMFR0,Processor Feature Register 0"
                    bitfld.long 0x00 24.--27. " FCSE       ,Fast Context Switch Memory Mappings Support" "Not supported,?..."
                    bitfld.long 0x00 20.--23. "  ACR        ,Auxiliary Control Register Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 16.--19. " TCM        ,TCM and Associated DMA Support" "Not supported,?..."
                    bitfld.long 0x00 12.--15. "  OSS        ,Outer Shareable Support" "Not supported,?..."
                    textline "                    "
                    bitfld.long 0x00 8.--11. " CC_CPUA    ,Cache Coherency Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 4.--7. "      PMSA       ,Physical Memory System Architecture (PMSA) Support" "Not supported,?..."
                    textline "                    "
                    bitfld.long 0x00 0.--3. " VMSA       ,Virtual Memory System Architecture (VMSA) Support" "Reserved,Reserved,Reserved,Supported,?..."            
                rgroup c14:0x34d--0x34d
                 line.long 0x00 "ID_MMFR1,Processor Feature Register 1"
                    bitfld.long 0x00 28.--31. " BTB        ,Branch Predictor" "Reserved,Reserved,Required,?..."
                    bitfld.long 0x00 24.--27. "       L1TCO      ,Test and Clean Operations on Data Cache/Harvard/Unified Architecture Support" "Not supported,?..."
                    textline "                    "
                    bitfld.long 0x00 20.--23. " L1UCMO     ,L1 Cache/All Maintenance Operations/Unified Architecture Support" "Not supported,?..."
                    bitfld.long 0x00 16.--19. "  L1HCMO     ,L1 Cache/All Maintenance Operations/Harvard Architecture Support" "Not supported,?..."
                    textline "                    "
                    bitfld.long 0x00 12.--15. " L1UCLMOSW  ,L1 Cache Line Maintenance Operations by Set and Way/Unified Architecture Support" "Not supported,?..."
                    bitfld.long 0x00 8.--11. "  L1HCLMOSW  ,L1 Cache Line Maintenance Operations by Set and Way/Harvard Architecture Support" "Not supported,?..."
                    textline "                    "
                    bitfld.long 0x00 4.--7. " L1UCLMOMVA ,L1 Cache Line Maintenance Operations by VA/Unified Architecture Support" "Not supported,?..."
                    bitfld.long 0x00 0.--3. "  L1HCLMOMVA ,L1 Cache Line Maintenance Operations by VA/Harvard Architecture" "Not supported,?..."    
                rgroup c14:0x34e--0x34e
                 line.long 0x00 "ID_MMFR2,Processor Feature Register 2"
                    bitfld.long 0x00 28.--31. " HAF        ,Hardware Access Flag Support" "Not supported,?..."
                    bitfld.long 0x00 24.--27. "  WFI        ,Wait for Interrupt Stalling Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 20.--23. " MBF        ,Memory Barrier Operations Support" "Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 16.--19. "      UTLBMO     ,TLB Maintenance Operations/Unified Architecture Support" "Reserved,Reserved,Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 12.--15. " HTLBMO     ,TLB Maintenance Operations/Harvard Architecture Support" "Not supported,?..."
                    bitfld.long 0x00 8.--11. "  HL1CMRO    ,Cache Maintenance Range Operations/Harvard Architecture Support" "Not supported,?..."
                    textline "                    "
                    bitfld.long 0x00 4.--7. " HL1BPCRO   ,Background Prefetch Cache Range Operations/Harvard Architecture Support" "Not supported,?..."
                    bitfld.long 0x00 0.--3. "  HL1FPCRO   ,Foreground Prefetch Cache Range Operations/Harvard Architecture Support" "Not supported,?..."
                rgroup c14:0x34f--0x34f
                 line.long 0x00 "ID_MMFR3,Processor Feature Register 3"
                    bitfld.long 0x00 28.--31. " SS         ,Supersection support" "Supported,?..."
                    bitfld.long 0x00 20.--23. "      CW         ,Coherent walk" "Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 12.--15. " MB         ,Invalidate broadcast Support" "Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 8.--11. "      BPM        ,Invalidate Branch predictor Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 4.--7. " HCMOSW     ,Invalidate Cache by Set and Way/Clean by Set and Way/Invalidate and Clean by Set and Way Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 0.--3. "      HCMOMVA    ,Invalidate Cache MVA Support" "Reserved,Supported,?..."                
                rgroup c14:0x350--0x350
                 line.long 0x00 "ID_ISAR0,ISA Feature Register 0"
                    bitfld.long 0x00 24.--27. " DIVI       ,Divide Instructions Support" "Not supported,?..."
                    bitfld.long 0x00 20.--23. "  DEBI       ,Debug Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 16.--19. " CI         ,Coprocessor Instructions Support" "Not supported,?..."
                    bitfld.long 0x00 12.--15. "  CBI        ,Combined Compare and Branch Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 8.--11. " BI         ,Bitfield Instructions Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 4.--7. "      BCI        ,Bit Counting Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 0.--3. " SI         ,Swap Instructions Support" "Reserved,Supported,?..."            
                rgroup c14:0x351--0x351
                 line.long 0x00 "ID_ISAR1,ISA Feature Register 1"
                    bitfld.long 0x00 28.--31. " JI         ,Jazelle Instructions Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 24.--27. "      INTI       ,Interwork Instructions Support" "Reserved,Reserved,Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 20.--23. " IMMI       ,Immediate Instructions Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 16.--19. "      ITEI       ,If Then Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 12.--15. " EXTI       ,Extend Instructions Support" "Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 8.--11. "      E2I        ,Exception 2 Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 4.--7. " E1I        ,Exception 1 Instructions Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 0.--3. "      ENDI       ,Endian Instructions Support" "Reserved,Supported,?..."            
                rgroup c14:0x352--0x352
                 line.long 0x00 "ID_ISAR2,ISA Feature Register 2"
                    bitfld.long 0x00 28.--31. " RI         ,Reversal Instructions Support" "Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 24.--27. "      PSRI       ,PSR Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 20.--23. " UMI        ,Advanced Unsigned Multiply Instructions Support" "Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 16.--19. "      SMI        ,Advanced Signed Multiply Instructions Support" "Reserved,Reserved,Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 12.--15. " MI         ,Multiply Instructions Support" "Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 8.--11. "      II         ,Multi-Access Interruptible Instructions Support" "Not supported,?..."
                    textline "                    "
                    bitfld.long 0x00 4.--7. " MHI        ,Memory Hint Instructions Support" "Reserved,Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 0.--3. "      LSI        ,Load and Store Instructions Support" "Reserved,Supported,?..."
                rgroup c14:0x353--0x353
                 line.long 0x00 "ID_ISAR3,ISA Feature Register 3"
                    bitfld.long 0x00 28.--31. " T2E        ,Thumb-2 Extensions Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 24.--27. "      NOPI       ,True NOP Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 20.--23. " TCI        ,Thumb Copy Instructions Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 16.--19. "      TBI        ,Table Branch Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 12.--15. " SPI        ,Synchronization Primitive Instructions Support" "Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 8.--11. "      SVCI       ,SVC Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 4.--7. " SIMDI      ,Single Instruction Multiple Data (SIMD) Instructions Support" "Reserved,Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 0.--3. "      SI         ,Saturate Instructions Support" "Reserved,Supported,?..."                
                rgroup c14:0x354--0x354
                 line.long 0x00 "ID_ISAR4,ISA Feature Register 4"
                    bitfld.long 0x00 28.--31. " SWP_frac   ,SWAP_frac" "Supported,?..."
                    bitfld.long 0x00 24.--27. "      PSR_M_I    ,PSR_M Instructions Support" "Not supported,?..."
                    textline "                    "
                    bitfld.long 0x00 20.--23. " SPRI       ,Synchronization Primitive instructions" "Not supported,?..."
                    bitfld.long 0x00 16.--19. "  BI         ,Barrier Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 12.--15. " SMCI       ,SMC Instructions Support" "Reserved,Supported,?..."
                    bitfld.long 0x00 8.--11. "      WBI        ,Write-Back Instructions Support" "Reserved,Supported,?..."
                    textline "                    "
                    bitfld.long 0x00 4.--7. " WSI        ,With-Shift Instructions Support" "Reserved,Reserved,Reserved,Reserved,Supported,?..."
                    bitfld.long 0x00 0.--3. "      UI         ,Unprivileged Instructions Support" "Reserved,Reserved,Supported,?..."                    
                rgroup c14:0x355--0x355
                 line.long 0x00 "ID_ISAR5,ISA Feature Register 5 (Reserrved)"
    tree.end

tree "Coresight Management Registers"
    width 17.

    textline "                          "

    group c14:0x03bd++0x00
        line.long 0x00 "DBGITCTRL_IOC,Integration Internal Output Control Register"
            bitfld.long 0x00 5. " I_DBGTRIGGER    ,Internal DBGTRIGGER" "0,1"
            bitfld.long 0x00 4. "                I_DBGRESTARTED  ,Internal DBGRESTARTED" "0,1"
              textline "                          "
            bitfld.long 0x00 3. " I_nPMUIRQ       ,Internal nPMUIRQ" "0,1"
            bitfld.long 0x00 2. "                InternalCOMMTX  ,Internal COMMTX" "0,1"
              textline "                          "
            bitfld.long 0x00 1. " I_COMMRX        ,Internal COMMRX" "0,1"
            bitfld.long 0x00 0. "                I_DBGACK        ,Internal DBGACK" "0,1"
    group c14:0x03be++0x00
        line.long 0x00 "DBGITCTRL_EOC,Integration External Output Control Register"
            bitfld.long 0x00 7. " nDMAEXTERRIQ    ,External nDMAEXTERRIRQ" "0,1"
            bitfld.long 0x00 6. "                nDMASIRQ        ,External nDMASIRQ" "0,1"
            textline "                          "
            bitfld.long 0x00 5. " nDMAIRQ         ,External nDMAIRQ" "0,1"
            bitfld.long 0x00 4. "                nPMUIRQ         ,External nPMUIRQ" "0,1"
            textline "                          "
            bitfld.long 0x00 3. " STANDBYWFI      ,External STANDBYWFI" "0,1"
            bitfld.long 0x00 2. "                COMMTX          ,External COMMTX" "0,1"
            textline "                          "
            bitfld.long 0x00 1. " COMMRX          ,External COMMRX" "0,1"
            bitfld.long 0x00 0. "                DBGACK          ,External DBGACK" "0,1"
    rgroup c14:0x03bf++0x00
        line.long 0x00 "DBGITCTRL_IS,Integration Input Status Register"
            bitfld.long 0x00 11. " CTI_DBGRESTART  ,CTI Debug Restart" "0,1"
            bitfld.long 0x00 10. "                CTI_EDBGRQ      ,CTI Debug Request" "0,1"
            textline "                          "
            bitfld.long 0x00 9. " CTI_PMUEXTIN[1] ,CTI PMUEXTIN[1] Signal" "0,1"
            bitfld.long 0x00 8. "                CTI_PMUEXTIN[0] ,CTI PMUEXTIN[0] Signal" "0,1"
            textline "                          "
            bitfld.long 0x00 2. " nFIQ            ,nFIQ Input" "0,1"
            bitfld.long 0x00 1. "                nIRQ            ,nIRQ Input" "0,1"
            textline "                          "
            bitfld.long 0x00 0. " EDBGRQ          ,EDBGRQ Input" "0,1"
    group c14:0x3c0--0x3c0
     line.long 0x0 "DBGITCTRL,Integration Mode Control Register"
      bitfld.long 0x0 0. " IME             ,Integration Mode Enable" "Disabled,Enabled"
    group c14:0x3e8--0x3e8
     line.long 0x0 "DBGCLAIMSET,Claim Tag Set Register"
      bitfld.long 0x0 7. " CT7             ,Claim Tag 7" "No Effect,Set"
      bitfld.long 0x0 6. "        CT6             ,Claim Tag 6" "No Effect,Set"
      textline "                          "
      bitfld.long 0x0 5. " CT5             ,Claim Tag 5" "No Effect,Set"
      bitfld.long 0x0 4. "        CT4             ,Claim Tag 4" "No Effect,Set"
      textline "                          "
      bitfld.long 0x0 3. " CT3             ,Claim Tag 3" "No Effect,Set"
      bitfld.long 0x0 2. "        CT2             ,Claim Tag 2" "No Effect,Set"
      textline "                          "
      bitfld.long 0x0 1. " CT1             ,Claim Tag 1" "No Effect,Set"
      bitfld.long 0x0 0. "        CT0             ,Claim Tag 0" "No Effect,Set"
    group c14:0x3e9--0x3e9
     line.long 0x0 "DBGCLAIMCLR,Claim Tag Clear Register"
      bitfld.long 0x0 7. " CT7             ,Claim Tag 7" "No Effect,Cleared"
      bitfld.long 0x0 6. "        CT6             ,Claim Tag 6" "No Effect,Cleared"
      textline "                          "
      bitfld.long 0x0 5. " CT5             ,Claim Tag 5" "No Effect,Cleared"
      bitfld.long 0x0 4. "        CT4             ,Claim Tag 4" "No Effect,Cleared"
      textline "                          "
      bitfld.long 0x0 3. " CT3             ,Claim Tag 3" "No Effect,Cleared"
      bitfld.long 0x0 2. "        CT2             ,Claim Tag 2" "No Effect,Cleared"
      textline "                          "
      bitfld.long 0x0 1. " CT1             ,Claim Tag 1" "No Effect,Cleared"
      bitfld.long 0x0 0. "        CT0             ,Claim Tag 0" "No Effect,Cleared"
    wgroup c14:0x3ec--0x3ec
     line.long 0x0 "DBGLAR,Lock Access Register"
      hexmask.long.long 0x0 0.--31. 1. " LACK            ,Lock Access Control Key"
    rgroup c14:0x3ed--0x3ed 
     line.long 0x0 "DBGLSR,Lock Status Register"
      bitfld.long 0x0 2. " 32ACND          ,32-bit Access Needed" "Needed,Not needed"
      bitfld.long 0x0 1. "       WLCK            ,Writes Lock" "Permitted,Ignored"
      textline "                          "
      bitfld.long 0x0 0. " LI              ,Lock Implementation" "Lock ignored,Unlock required"
width 17.
    rgroup c14:0x3ee--0x3ee
     line.long 0x0 "DBGAUTHSTATUS,Authentication Status Register"
      bitfld.long 0x0 7. " SNIDFI  ,Secure Non-invasive Debug Features Implemented" "Not Implemented,Implemented"
      bitfld.long 0x0 6. "  SNIDE  ,Secure Non-invasive Debug Enable" "Disabled,Enabled"
      textline "                          "
      bitfld.long 0x0 5. " SIDFI   ,Secure Invasive Debug Feauter Implemented" "Not Implemented,Implemented"
      bitfld.long 0x0 4. "  SIDE   ,Secure Invasive Debug Enable" "Disabled,Enabled"
      textline "                          "
      bitfld.long 0x0 3. " NSNIDFI ,Non-secure Non-invasive Debug Feature Implemented" "Not Implemented,Implemented"
      bitfld.long 0x0 2. "  NSNIDE ,Non-secure Non-invasive Debug Enable" "Disabled,Enabled"
      textline "                          "
      bitfld.long 0x0 1. " NSIDFI  ,Non-secure Invasive Debug Implemented" "Not Implemented,Implemented"
      bitfld.long 0x0 0. "  NSIDE  ,Non-secure Invasive Debug Enable" "Disabled,Enabled"
width 17.
    hgroup c14:0x3f2--0x3f2
     hide.long 0x0 "DBGDEVID,Device Identifier (RESERVED)"
    rgroup c14:0x3f3--0x3f3
     line.long 0x0 "DBGDEVTYPE,Device Type"
      hexmask.long.byte 0x0 4.--7. 1. " STPC   ,Sub Type: Processor Core"
      hexmask.long.byte 0x0 0.--3. 1. "     MCDL   ,Main Class: Debug Logic"

            rgroup c14:0x3f8--0x3f8
             line.long 0x0 "DBGPID0,Peripherial ID0"
              hexmask.long.byte 0x0 0.--7. 1. " PN     ,Part Number [7:0]"
            rgroup c14:0x3f9--0x3f9  
             line.long 0x0 "DBGPID1,Peripherial ID1"
              hexmask.long.byte 0x0 4.--7. 1. " JEP106 ,JEP106 Identity Code [3:0]"
              hexmask.long.byte 0x0 0.--3. 1. "     PN     ,Part Number [11:8]"
            rgroup c14:0x3fa--0x3fa
             line.long 0x0 "DBGPID2,Peripherial ID2"
              hexmask.long.byte 0x0 4.--7. 1. " REV    ,Revision"
              hexmask.long.byte 0x0 0.--2. 1. "     JEP106 ,JEP106 Identity Code [6:4]"
            rgroup c14:0x3fb--0x3fb
             line.long 0x0 "DBGPID3,Peripherial ID3"
              hexmask.long.byte 0x0 4.--7. 1. " REVA   ,RevAnd"
              hexmask.long.byte 0x0 0.--3. 1. "     CMOD   ,Customer Modified"
            rgroup c14:0x3f4--0x3f4
             line.long 0x0 "DBGPID4,Peripherial ID4"
              bitfld.long 0x0 4.--7. " 4KBC   ,Number of 4KB Blocks Occupied" "1,2,4,8,16,32,64,128,256,512,1024,2048,4096,8192,16384,32768"
              bitfld.long 0x0 0.--3. "  JEP106 ,JEP106 Continuation Code" "0000,0001,0010,0011,0100,0101,0110,0111,1000,1001,1010,1011,1100,1101,1110,1111"
            rgroup c14:0x3fc--0x3fc
             line.long 0x0 "DBGCOMPONENTID0,Component ID0"
              hexmask.long.byte 0x0 0.--7. 1. " PRBL   ,Preamble"
            rgroup c14:0x3fd--0x3fd
             line.long 0x0 "DBGCOMPONENTID1,Component ID1"
              hexmask.long.byte 0x0 4.--7. 1. " CCLASS ,Component Class (CoreSight Component)"
              hexmask.long.byte 0x0 0.--3. 1. "     PRBL   ,Preamble"
            rgroup c14:0x3fe--0x3fe
             line.long 0x0 "DBGCOMPONENTID2,Component ID2"
              hexmask.long.byte 0x0 0.--7. 1. " PRBL   ,Preamble"
            rgroup c14:0x3ff--0x3ff
             line.long 0x0 "DBGCOMPONENTID3,Component ID3"
              hexmask.long.byte 0x0 0.--7. 1. " PRBL   ,Preamble"
tree.end

tree.end

width 6.
tree "Breakpoint Registers"
    group c14:0x40++0x00
        line.long 0x00 "BVR0,Breakpoint Value Register 0"
            hexmask.long 0x00 0.--31. 1. " BV0 ,Breakpoint Value 0"
    group c14:0x50++0x00
        line.long 0x00 "BCR0,Breakpoint Control Register 0"
            bitfld.long 0x00 20.--22. " M   ,BVR Meaning" "IVA match,Linked IVA match,Reserved,Reserved,IVA mismatch,Linked IVA mismatch,?..."
            bitfld.long 0x00 16.--19. "     LBRP ,Linked BRP Number" "BRP,BRP1,BRP2,BRP3,BRP4,BRP5,BRP6,BRP7,BRP8,BRP9,BRP10,BRP11,BRP12,BRP13,BRP14,BRP15"
            bitfld.long 0x00 14.--15. "     SWAC ,Secure World Access Control" "Both,Nonsecure,Secure,?..."
            textline "               "
            bitfld.long 0x0 8. " BAS ,Byte 3 address select" "0,1"
            bitfld.long 0x0 7. ",Byte 2 address select" "0,1"
             bitfld.long 0x0 6. ",Byte 1 address select" "0,1"
             bitfld.long 0x0 5. ",Byte 0 address select" "0,1"
            bitfld.long 0x00 1.--2. "        S  ,Supervisor Access Control" "User/system/supervisor,Privileged,User,Any"
            bitfld.long 0x00 0. "  B    ,Breakpoint Enable" "Disabled,Enabled"
    group c14:0x41++0x00
        line.long 0x00 "BVR1,Breakpoint Value Register 1"
            hexmask.long 0x00 0.--31. 1. " BV1 ,Breakpoint Value 1"
    group c14:0x51++0x00
        line.long 0x00 "BCR1,Breakpoint Control Register 1"
            bitfld.long 0x00 20.--22. " M   ,BVR Meaning" "IVA match,Linked IVA match,Reserved,Reserved,IVA mismatch,Linked IVA mismatch,?..."
            bitfld.long 0x00 16.--19. "     LBRP ,Linked BRP Number" "BRP,BRP1,BRP2,BRP3,BRP4,BRP5,BRP6,BRP7,BRP8,BRP9,BRP10,BRP11,BRP12,BRP13,BRP14,BRP15"
            bitfld.long 0x00 14.--15. "     SWAC ,Secure World Access Control" "Both,Nonsecure,Secure,?..."
            textline "               "
            bitfld.long 0x0 8. " BAS ,Byte 3 address select" "0,1"
            bitfld.long 0x0 7. ",Byte 2 address select" "0,1"
             bitfld.long 0x0 6. ",Byte 1 address select" "0,1"
             bitfld.long 0x0 5. ",Byte 0 address select" "0,1"
            bitfld.long 0x00 1.--2. "        S  ,Supervisor Access Control" "User/system/supervisor,Privileged,User,Any"
            bitfld.long 0x00 0. "  B    ,Breakpoint Enable" "Disabled,Enabled"
    group c14:0x42++0x00
        line.long 0x00 "BVR2,Breakpoint Value Register 2"
            hexmask.long 0x00 0.--31. 1. " BV2 ,Breakpoint Value 2"
    group c14:0x52++0x00
        line.long 0x00 "BCR2,Breakpoint Control Register 2"
            bitfld.long 0x00 20.--22. " M   ,BVR Meaning" "IVA match,Linked IVA match,Reserved,Reserved,IVA mismatch,Linked IVA mismatch,?..."
            bitfld.long 0x00 16.--19. "     LBRP ,Linked BRP Number" "BRP,BRP1,BRP2,BRP3,BRP4,BRP5,BRP6,BRP7,BRP8,BRP9,BRP10,BRP11,BRP12,BRP13,BRP14,BRP15"
            bitfld.long 0x00 14.--15. "     SWAC ,Secure World Access Control" "Both,Nonsecure,Secure,?..."
            textline "               "
            bitfld.long 0x0 8. " BAS ,Byte 3 address select" "0,1"
            bitfld.long 0x0 7. ",Byte 2 address select" "0,1"
             bitfld.long 0x0 6. ",Byte 1 address select" "0,1"
             bitfld.long 0x0 5. ",Byte 0 address select" "0,1"
            bitfld.long 0x00 1.--2. "        S  ,Supervisor Access Control" "User/system/supervisor,Privileged,User,Any"
            bitfld.long 0x00 0. "  B    ,Breakpoint Enable" "Disabled,Enabled"
tree.end

width 6.
tree "Watchpoint Control Registers"
    group c14:0x60++0x00
        line.long 0x00 "WVR0,Watchpoint Value Register 0"
            hexmask.long 0x00 2.--31. 0x04 " WA0   ,Watchpoint Address 0"
    group c14:0x70--0x70
     line.long 0x0 "WCR0,Watchpoint Control Register 0"
      bitfld.long 0x0 20. " EL    ,Enable Linking" "Disabled,Enabled"
       textline "               "
      bitfld.long 0x0 16.--19. " LBN   ,Linked BRP number" "BRP,BRP1,BRP2,BRP3,BRP4,BRP5,BRP6,BRP7,BRP8,BRP9,BRP10,BRP11,BRP12,BRP13,BRP14,BRP15"
      bitfld.long 0x0 14.--15. "       SWAC ,Secure world access control" "Non-secure & Secure,Non-secure,Secure,?..."
       textline "               "
      bitfld.long 0x0 12. " BAS   ,Byte 7 address select" "0,1"
      bitfld.long 0x0 11. ",Byte 6 address select" "0,1"
      bitfld.long 0x0 10. ",Byte 5 address select" "0,1"
      bitfld.long 0x0 9. ",Byte 4 address select" "0,1"
      bitfld.long 0x0 8. ",Byte 3 address select" "0,1"
      bitfld.long 0x0 7. ",Byte 2 address select" "0,1"
      bitfld.long 0x0 6. ",Byte 1 address select" "0,1"
      bitfld.long 0x0 5. ",Byte 0 address select" "0,1"
     textline "               "
      bitfld.long 0x0 3.--4. " RD/WR ,Load/Store access control" "Reserved,Load,Store,Any"
      bitfld.long 0x0 1.--2. "    PAC  ,Privileged access control" "Reserved,Privileged,USR,Any"
       textline "               "
      bitfld.long 0x0 0. " WE    ,Watchpoint enable" "Disabled,Enabled"
    group c14:0x61++0x00
        line.long 0x00 "WVR1,Watchpoint Value Register 1"
            hexmask.long 0x00 2.--31. 0x04 " WA1   ,Watchpoint Address 1"
    group c14:0x71--0x71
     line.long 0x0 "WCR1,Watchpoint Control Register 1"
      bitfld.long 0x0 20. " EL    ,Enable Linking" "Disabled,Enabled"
       textline "               "
      bitfld.long 0x0 16.--19. " LBN   ,Linked BRP number" "BRP,BRP1,BRP2,BRP3,BRP4,BRP5,BRP6,BRP7,BRP8,BRP9,BRP10,BRP11,BRP12,BRP13,BRP14,BRP15"
      bitfld.long 0x0 14.--15. "       SWAC ,Secure world access control" "Non-secure & Secure,Non-secure,Secure,?..."
       textline "               "
      bitfld.long 0x0 12. " BAS   ,Byte 7 address select" "0,1"
      bitfld.long 0x0 11. ",Byte 6 address select" "0,1"
      bitfld.long 0x0 10. ",Byte 5 address select" "0,1"
      bitfld.long 0x0 9. ",Byte 4 address select" "0,1"
      bitfld.long 0x0 8. ",Byte 3 address select" "0,1"
      bitfld.long 0x0 7. ",Byte 2 address select" "0,1"
      bitfld.long 0x0 6. ",Byte 1 address select" "0,1"
      bitfld.long 0x0 5. ",Byte 0 address select" "0,1"
     textline "               "
      bitfld.long 0x0 3.--4. " RD/WR ,Load/Store access control" "Reserved,Load,Store,Any"
      bitfld.long 0x0 1.--2. "    PAC  ,Privileged access control" "Reserved,Privileged,USR,Any"
       textline "               "
      bitfld.long 0x0 0. " WE    ,Watchpoint enable" "Disabled,Enabled"
    group c14:0x006--0x006
        line.long 0x0 "WFAR,Watchpoint Fault Address Register"
        hexmask.long.long 0x00 1.--31. 0x02 " WFAR  ,Address of the watchpointed instruction"
    textline " "

tree.end
width 0xb


width 9.

base ad:(d.l(c15:0x400f))
tree "Snoop Control Unit (SCU)"
group.long 0x00++0x03
    line.long 0x00 "SCUCR,SCU Control Register"
        bitfld.long 0x00 2. " PON   ,Parity ON" "Off,On"
        bitfld.long 0x00 1. "                AFEN  ,Address filtering enable" "Off,On"
        bitfld.long 0x00 0. "                SCUEN ,SCU enable" "Disabled,Enabled"
rgroup.long 0x04++0x03
    line.long 0x00 "SCUCON,SCU Configuration Register"
        bitfld.long 0x00 14.--15. " RAM3  ,Cortex-A9 CPU3 Tag RAM Size" "16KB,32KB,Reserved,64KB"
        bitfld.long 0x00 12.--13. "           RAM2  ,Cortex-A9 CPU2 Tag RAM Size" "16KB,32KB,Reserved,64KB"
        bitfld.long 0x00 10.--11. "           RAM1  ,Cortex-A9 CPU1 Tag RAM Size" "16KB,32KB,Reserved,64KB"
        textline "                  "
        bitfld.long 0x00 8.--9. " RAM0  ,Cortex-A9 CPU0 Tag RAM Size" "16KB,32KB,Reserved,64KB"
        bitfld.long 0x00 7. "           MOD3  ,CPU3 Mode" "AMP,SMP"
        bitfld.long 0x00 6. "                MOD2  ,CPU2 Mode" "AMP,SMP"
        textline "                  "
        bitfld.long 0x00 5. " MOD1  ,CPU1 Mode" "AMP,SMP"
        bitfld.long 0x00 4. "                MOD0  ,CPU0 Mode" "AMP,SMP"
        bitfld.long 0x00 0.--1. "                NUM   ,CPU Number" "CPU0,CPU0-CPU1,CPU0-CPU2,CPU0-CPU3"
group.long 0x08++0x03
    line.long 0x00 "SCUSTAT,SCU CPU Power Status Register"
        bitfld.long 0x00 24.--25. " STAT3 ,CPU3 Status" "Normal,Reserved,Dormant,Powered-off"
        bitfld.long 0x00 16.--17. "        STAT2 ,CPU2 Status" "Normal,Reserved,Dormant,Powered-off"
        textline "                  "
        bitfld.long 0x00 8.--9. " STAT1 ,CPU1 Status" "Normal,Reserved,Dormant,Powered-off"
        bitfld.long 0x00 0.--1. "        STAT0 ,CPU0 Status" "Normal,Reserved,Dormant,Powered-off"
wgroup.long 0x0c++0x03
    line.long 0x00 "INV,SCU Invalidate All Register"
        bitfld.long 0x00 12.--15. " WAY3  ,Cortex-A9 CPU3 Invalidated Ways" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "                 WAY2  ,Cortex-A9 CPU2 Invalidated Ways" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "                 WAY1  ,Cortex-A9 CPU1 Invalidated Ways" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                  "
        bitfld.long 0x00 0.--3. " WAY0  ,Cortex-A9 CPU0 Invalidated Ways" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.long 0x40++0x03
    line.long 0x00 "FSAR,Filtering Start Address Register"
        hexmask.long.word 0x00 20.--31. 0x10 " FSA   ,Filtering start address"
group.long 0x44++0x03        
    line.long 0x00 "FEAR,Filtering End Address Register"
        hexmask.long.word 0x00 20.--31. 0x10 " FEA   ,Filtering end address"
group.long 0x50++0x03
    line.long 0x00 "SAC,SCU Access Control Register"
        bitfld.long 0x00 3. " CPU3  ,CPU3 Access the SAC" "No access,Access"
        bitfld.long 0x00 2. "          CPU2  ,CPU2 Access the SAC" "No access,Access"
        bitfld.long 0x00 1. "          CPU1  ,CPU1 Access the SAC" "No access,Access"
        textline "                  "
        bitfld.long 0x00 0. " CPU0  ,CPU0 Access the SAC" "No access,Access"
group.long 0x54++0x03        
    line.long 0x00 "SSAC,SCU Secure Access Control Register"
        bitfld.long 0x00 11. " GCPU3 ,Global timer for CPU3" "Secure only,Secure/Non-secure"
        bitfld.long 0x00 10. "  GCPU2 ,Global timer for CPU2" "Secure only,Secure/Non-secure"
        bitfld.long 0x00 9. "  GCPU1 ,Global timer for CPU1" "Secure only,Secure/Non-secure"
        textline "                  "
        bitfld.long 0x00 8. " GCPU0 ,Global timer for CPU0" "Secure only,Secure/Non-secure"
        bitfld.long 0x00 7. "  TCPU3 ,Private timer for CPU3 Access" "Secure only,Secure/Non-secure"
        bitfld.long 0x00 6. "  TCPU2 ,Private timer for CPU2 Access" "Secure only,Secure/Non-secure"
        textline "                  "
        bitfld.long 0x00 5. " TCPU1 ,Private timer for CPU1 Access" "Secure only,Secure/Non-secure"
        bitfld.long 0x00 4. "  TCPU0 ,Private timer for CPU0 Access" "Secure only,Secure/Non-secure"
        bitfld.long 0x00 3. "  CPU3  ,CPU3 Access the SAC" "No access,Access"
        textline "                  "
        bitfld.long 0x00 2. " CPU2  ,CPU2 Access the SAC" "No access,Access"
        bitfld.long 0x00 1. "          CPU1  ,CPU1 Access the SAC" "No access,Access"
        bitfld.long 0x00 0. "          CPU0  ,CPU0 Access the SAC" "No access,Access"
tree.end 
width 0xb    


base ad:(d.l(c15:0x400f))+0x1000

width 9.

tree "Distributed Interrupt Controller"
group.long 0x00++0x03
    line.long 0x00 "ICDDCR,Interrupt Distributor Control Register"
        bitfld.long 0x00 0. " EN             ,Enable" "Disabled,Enabled"
rgroup.long 0x04++0x03
    line.long 0x00 "ICDICTR,Interrupt Controller Type Register"
        bitfld.long 0x00 11.--15. " LSPI           ,Returns the number of LSPIs that the controller contains" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 10. "            Domains       ,Returns the number of security domains that the controller contains" "0,2"
        bitfld.long 0x00 5.--7. "             CPU           ,CPU Number" "1,2,3,4,?..."
        textline "                  "
        bitfld.long 0x00 0.--4. " LINE           ,IT Lines Number" "32,64,96,128,160,192,224,256,?..."        
rgroup.long 0x08++0x03        
    line.long 0x00 "ICDDIR,Distributor Implementer Identification Register"
        hexmask.long.word 0x00 24.--31. 1. " IMPD           ,Implementation Defined"
        hexmask.long.word 0x00 12.--23. 1. "          REV           ,Revision Number"
        hexmask.long.word 0x00 0.--11. 1. "          IMP           ,Implementer Number"
wgroup.long 0xf00++0x03
    line.long 0x00 "SINT,Software Interrupt Register"
        bitfld.long 0x00 24.--25. " TLF            ,Target List Filter" "Listed,All other,Specified,?..."
        bitfld.long 0x00 19. "     TL[3]         ,CPU Target List Interrupt Interface 3" "No interrupt,Interrupt"
        bitfld.long 0x00 18. "  TL[2]         ,CPU Target List Interrupt Interface 2" "No interrupt,Interrupt"
        textline "                  "
        bitfld.long 0x00 17. " TL[1]          ,CPU Target List Interrupt Interface 1" "No interrupt,Interrupt"
        bitfld.long 0x00 16. "  TL[0]         ,CPU Target List Interrupt Interface 0" "No interrupt,Interrupt"
        bitfld.long 0x00 15. "  SATT          ,Security ATTribute" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 0.--3. " ID             ,Interrupt ID" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        
rgroup.long 0xfe0++0x03
    line.long 0x00 "PIR0,Peripheral Identification Register 0"
        hexmask.long 0x00 0.--7. 0x1 " part_number_0  ,Identifies the peripheral"
rgroup.long 0xfe4++0x03
    line.long 0x00 "PIR1,Peripheral Identification Register 1"
        hexmask.long.byte 0x00 4.--7. 0x1 " jep106_id_3_0  ,JEP106 identity code [3:0]"
        hexmask.long.byte 0x00 0.--3. 0x1 "            part_number_1 ,Identifies the peripheral"
rgroup.long 0xfe8++0x03
    line.long 0x00 "PIR2,Peripheral Identification Register 2"
        hexmask.long.byte 0x00 4.--7. 1. " architecture   ,Architecture number"
        bitfld.long 0x00 3. "            jedec_used    ,Identifies if the GIC uses the JEP106 manufacturer identity code" "Not used,Used"
        hexmask.long.byte 0x00 0.--2. 1. "      jep106_id_6_4 ,JEP106 identity code [6:4]"
rgroup.long 0xfec++0x03
    line.long 0x00 "PIR3,Peripheral Identification Register 3"
        hexmask.long.byte    0x00 4.--7. 1. " RevAnd         ,Identifies the manufacturer revision number"
        hexmask.long.byte 0x00 0.--3. 1. "            mod_number    ,Identifies data that is relevant to the ARM partner"
rgroup.long 0xff0++0x03
    line.long 0x00 "PCIR0,PrimeCell Identification Register 0"
        hexmask.long.byte 0x00 0.--7. 0x1 " component_id_0 ,Component id 0"
rgroup.long 0xff4++0x03        
    line.long 0x00 "PCIR1,PrimeCell Identification Register 1"    
        hexmask.long.byte 0x00 0.--7. 0x1 " component_id_1 ,Component id 1"
rgroup.long 0xff8++0x03        
    line.long 0x00 "PCIR2,PrimeCell Identification Register 2"        
        hexmask.long.byte 0x00 0.--7. 0x1 " component_id_2 ,Component id 2"
rgroup.long 0xffc++0x03        
    line.long 0x00 "PCIR3,PrimeCell Identification Register 3"        
        hexmask.long.byte 0x00 0.--7. 0x1 " component_id_3 ,Component id 3"
width 9.
tree "Interrupt Security Registers"
group.long 0x80++0x03
    line.long 0x00 "ICDISR0,Interrupt Security Register[0]"
        bitfld.long 0x00 31. " ITSP[3]  ,Interrupt Secure PPI[3]" "Secured,Non-secured"
        bitfld.long 0x00 30. "  ITSP[2]  ,Interrupt Secure PPI[2]" "Secured,Non-secured"
        bitfld.long 0x00 29. "  ITSP[1]  ,Interrupt Secure PPI[1]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 28. " ITSP[0]  ,Interrupt Secure PPI[0]" "Secured,Non-secured"
        bitfld.long 0x00 15. "  ITSS[15] ,Interrupt Secure SFI[15]" "Secured,Non-secured"
        bitfld.long 0x00 14. "  ITSS[14] ,Interrupt Secure SFI[14]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 13. " ITSS[13] ,Interrupt Secure SFI[13]" "Secured,Non-secured"
        bitfld.long 0x00 12. "  ITSS[12] ,Interrupt Secure SFI[12]" "Secured,Non-secured"
        bitfld.long 0x00 11. "  ITSS[11] ,Interrupt Secure SFI[11]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 10. " ITSS[10] ,Interrupt Secure SFI[10]" "Secured,Non-secured"
        bitfld.long 0x00 9. "  ITSS[9]  ,Interrupt Secure SFI[9]" "Secured,Non-secured"
        bitfld.long 0x00 8. "  ITSS[8]  ,Interrupt Secure SFI[8]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 7. " ITSS[7]  ,Interrupt Secure SFI[7]" "Secured,Non-secured"
        bitfld.long 0x00 6. "  ITSS[6]  ,Interrupt Secure SFI[6]" "Secured,Non-secured"
        bitfld.long 0x00 5. "  ITSS[5]  ,Interrupt Secure SFI[5]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 4. " ITSS[4]  ,Interrupt Secure SFI[4]" "Secured,Non-secured"
        bitfld.long 0x00 3. "  ITSS[3]  ,Interrupt Secure SFI[3]" "Secured,Non-secured"
        bitfld.long 0x00 2. "  ITSS[2]  ,Interrupt Secure SFI[2]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 1. " ITSS[1]  ,Interrupt Secure SFI[1]" "Secured,Non-secured"
        bitfld.long 0x00 0. "  ITSS[0]  ,Interrupt Secure SFI[0]" "Secured,Non-secured"
group.long 0x84++0x03
    line.long 0x00 "ICDISR1,Interrupt Security Register[1]"    
        bitfld.long 0x00 31. " ITS[31]  ,Interrupt Secure SPI[31]" "Secured,Non-secured"
        bitfld.long 0x00 30. "  ITS[30]  ,Interrupt Secure SPI[30]" "Secured,Non-secured"
        bitfld.long 0x00 29. "  ITS[29]  ,Interrupt Secure SPI[29]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 28. " ITS[28]  ,Interrupt Secure SPI[28]" "Secured,Non-secured"
        bitfld.long 0x00 27. "  ITS[27]  ,Interrupt Secure SPI[27]" "Secured,Non-secured"
        bitfld.long 0x00 26. "  ITS[26]  ,Interrupt Secure SPI[26]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 25. " ITS[25]  ,Interrupt Secure SPI[25]" "Secured,Non-secured"
        bitfld.long 0x00 24. "  ITS[24]  ,Interrupt Secure SPI[24]" "Secured,Non-secured"
        bitfld.long 0x00 23. "  ITS[23]  ,Interrupt Secure SPI[23]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 22. " ITS[22]  ,Interrupt Secure SPI[22]" "Secured,Non-secured"
        bitfld.long 0x00 21. "  ITS[21]  ,Interrupt Secure SPI[21]" "Secured,Non-secured"
        bitfld.long 0x00 20. "  ITS[20]  ,Interrupt Secure SPI[20]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 19. " ITS[19]  ,Interrupt Secure SPI[19]" "Secured,Non-secured"
        bitfld.long 0x00 18. "  ITS[18]  ,Interrupt Secure SPI[18]" "Secured,Non-secured"
        bitfld.long 0x00 17. "  ITS[17]  ,Interrupt Secure SPI[17]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 16. " ITS[16]  ,Interrupt Secure SPI[16]" "Secured,Non-secured"
        bitfld.long 0x00 15. "  ITS[15]  ,Interrupt Secure SPI[15]" "Secured,Non-secured"
        bitfld.long 0x00 14. "  ITS[14]  ,Interrupt Secure SPI[14]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 13. " ITS[13]  ,Interrupt Secure SPI[13]" "Secured,Non-secured"
        bitfld.long 0x00 12. "  ITS[12]  ,Interrupt Secure SPI[12]" "Secured,Non-secured"
        bitfld.long 0x00 11. "  ITS[11]  ,Interrupt Secure SPI[11]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 10. " ITS[10]  ,Interrupt Secure SPI[10]" "Secured,Non-secured"
        bitfld.long 0x00 9. "  ITS[9]   ,Interrupt Secure SPI[9]" "Secured,Non-secured"
        bitfld.long 0x00 8. "  ITS[8]   ,Interrupt Secure SPI[8]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 7. " ITS[7]   ,Interrupt Secure SPI[7]" "Secured,Non-secured"
        bitfld.long 0x00 6. "  ITS[6]   ,Interrupt Secure SPI[6]" "Secured,Non-secured"
        bitfld.long 0x00 5. "  ITS[5]   ,Interrupt Secure SPI[5]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 4. " ITS[4]   ,Interrupt Secure SPI[4]" "Secured,Non-secured"
        bitfld.long 0x00 3. "  ITS[3]   ,Interrupt Secure SPI[3]" "Secured,Non-secured"
        bitfld.long 0x00 2. "  ITS[2]   ,Interrupt Secure SPI[2]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 1. " ITS[1]   ,Interrupt Secure SPI[1]" "Secured,Non-secured"
        bitfld.long 0x00 0. "  ITS[0]   ,Interrupt Secure SPI[0]" "Secured,Non-secured"        
group.long 0x88++0x03
    line.long 0x00 "ICDISR2,Interrupt Security Register[2]"
        bitfld.long 0x00 31. " ITS[63]  ,Interrupt Secure SPI[63]" "Secured,Non-secured"
        bitfld.long 0x00 30. "  ITS[62]  ,Interrupt Secure SPI[62]" "Secured,Non-secured"
        bitfld.long 0x00 29. "  ITS[61]  ,Interrupt Secure SPI[61]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 28. " ITS[60]  ,Interrupt Secure SPI[60]" "Secured,Non-secured"
        bitfld.long 0x00 27. "  ITS[59]  ,Interrupt Secure SPI[59]" "Secured,Non-secured"
        bitfld.long 0x00 26. "  ITS[58]  ,Interrupt Secure SPI[58]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 25. " ITS[57]  ,Interrupt Secure SPI[57]" "Secured,Non-secured"
        bitfld.long 0x00 24. "  ITS[56]  ,Interrupt Secure SPI[56]" "Secured,Non-secured"
        bitfld.long 0x00 23. "  ITS[55]  ,Interrupt Secure SPI[55]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 22. " ITS[54]  ,Interrupt Secure SPI[54]" "Secured,Non-secured"
        bitfld.long 0x00 21. "  ITS[53]  ,Interrupt Secure SPI[53]" "Secured,Non-secured"
        bitfld.long 0x00 20. "  ITS[52]  ,Interrupt Secure SPI[52]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 19. " ITS[51]  ,Interrupt Secure SPI[51]" "Secured,Non-secured"
        bitfld.long 0x00 18. "  ITS[50]  ,Interrupt Secure SPI[50]" "Secured,Non-secured"
        bitfld.long 0x00 17. "  ITS[49]  ,Interrupt Secure SPI[49]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 16. " ITS[48]  ,Interrupt Secure SPI[48]" "Secured,Non-secured"
        bitfld.long 0x00 15. "  ITS[47]  ,Interrupt Secure SPI[47]" "Secured,Non-secured"
        bitfld.long 0x00 14. "  ITS[46]  ,Interrupt Secure SPI[46]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 13. " ITS[45]  ,Interrupt Secure SPI[45]" "Secured,Non-secured"
        bitfld.long 0x00 12. "  ITS[44]  ,Interrupt Secure SPI[44]" "Secured,Non-secured"
        bitfld.long 0x00 11. "  ITS[43]  ,Interrupt Secure SPI[43]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 10. " ITS[42]  ,Interrupt Secure SPI[42]" "Secured,Non-secured"
        bitfld.long 0x00 9. "  ITS[41]  ,Interrupt Secure SPI[41]" "Secured,Non-secured"
        bitfld.long 0x00 8. "  ITS[40]  ,Interrupt Secure SPI[40]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 7. " ITS[39]  ,Interrupt Secure SPI[39]" "Secured,Non-secured"
        bitfld.long 0x00 6. "  ITS[38]  ,Interrupt Secure SPI[38]" "Secured,Non-secured"
        bitfld.long 0x00 5. "  ITS[37]  ,Interrupt Secure SPI[37]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 4. " ITS[36]  ,Interrupt Secure SPI[36]" "Secured,Non-secured"
        bitfld.long 0x00 3. "  ITS[35]  ,Interrupt Secure SPI[35]" "Secured,Non-secured"
        bitfld.long 0x00 2. "  ITS[34]  ,Interrupt Secure SPI[34]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 1. " ITS[33]  ,Interrupt Secure SPI[33]" "Secured,Non-secured"
        bitfld.long 0x00 0. "  ITS[32]  ,Interrupt Secure SPI[32]" "Secured,Non-secured"
group.long 0x8c++0x03
    line.long 0x00 "ICDISR3,Interrupt Security Register[3]"
        bitfld.long 0x00 31. " ITS[95]  ,Interrupt Secure SPI[95]" "Secured,Non-secured"
        bitfld.long 0x00 30. "  ITS[94]  ,Interrupt Secure SPI[94]" "Secured,Non-secured"
        bitfld.long 0x00 29. "  ITS[93]  ,Interrupt Secure SPI[93]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 28. " ITS[92]  ,Interrupt Secure SPI[92]" "Secured,Non-secured"
        bitfld.long 0x00 27. "  ITS[91]  ,Interrupt Secure SPI[91]" "Secured,Non-secured"
        bitfld.long 0x00 26. "  ITS[90]  ,Interrupt Secure SPI[90]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 25. " ITS[89]  ,Interrupt Secure SPI[89]" "Secured,Non-secured"
        bitfld.long 0x00 24. "  ITS[88]  ,Interrupt Secure SPI[88]" "Secured,Non-secured"
        bitfld.long 0x00 23. "  ITS[87]  ,Interrupt Secure SPI[87]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 22. " ITS[86]  ,Interrupt Secure SPI[86]" "Secured,Non-secured"
        bitfld.long 0x00 21. "  ITS[85]  ,Interrupt Secure SPI[85]" "Secured,Non-secured"
        bitfld.long 0x00 20. "  ITS[84]  ,Interrupt Secure SPI[84]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 19. " ITS[83]  ,Interrupt Secure SPI[83]" "Secured,Non-secured"
        bitfld.long 0x00 18. "  ITS[82]  ,Interrupt Secure SPI[82]" "Secured,Non-secured"
        bitfld.long 0x00 17. "  ITS[81]  ,Interrupt Secure SPI[81]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 16. " ITS[80]  ,Interrupt Secure SPI[80]" "Secured,Non-secured"
        bitfld.long 0x00 15. "  ITS[79]  ,Interrupt Secure SPI[79]" "Secured,Non-secured"
        bitfld.long 0x00 14. "  ITS[78]  ,Interrupt Secure SPI[78]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 13. " ITS[77]  ,Interrupt Secure SPI[77]" "Secured,Non-secured"
        bitfld.long 0x00 12. "  ITS[76]  ,Interrupt Secure SPI[76]" "Secured,Non-secured"
        bitfld.long 0x00 11. "  ITS[75]  ,Interrupt Secure SPI[75]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 10. " ITS[74]  ,Interrupt Secure SPI[74]" "Secured,Non-secured"
        bitfld.long 0x00 9. "  ITS[73]  ,Interrupt Secure SPI[73]" "Secured,Non-secured"
        bitfld.long 0x00 8. "  ITS[72]  ,Interrupt Secure SPI[72]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 7. " ITS[71]  ,Interrupt Secure SPI[71]" "Secured,Non-secured"
        bitfld.long 0x00 6. "  ITS[70]  ,Interrupt Secure SPI[70]" "Secured,Non-secured"
        bitfld.long 0x00 5. "  ITS[69]  ,Interrupt Secure SPI[69]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 4. " ITS[68]  ,Interrupt Secure SPI[68]" "Secured,Non-secured"
        bitfld.long 0x00 3. "  ITS[67]  ,Interrupt Secure SPI[67]" "Secured,Non-secured"
        bitfld.long 0x00 2. "  ITS[66]  ,Interrupt Secure SPI[66]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 1. " ITS[65]  ,Interrupt Secure SPI[65]" "Secured,Non-secured"
        bitfld.long 0x00 0. "  ITS[64]  ,Interrupt Secure SPI[64]" "Secured,Non-secured"
group.long 0x90++0x03
    line.long 0x00 "ICDISR4,Interrupt Security Register[4]"
        bitfld.long 0x00 31. " ITS[127] ,Interrupt Secure SPI[127]" "Secured,Non-secured"
        bitfld.long 0x00 30. "  ITS[126] ,Interrupt Secure SPI[126]" "Secured,Non-secured"
        bitfld.long 0x00 29. "  ITS[125] ,Interrupt Secure SPI[125]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 28. " ITS[124] ,Interrupt Secure SPI[124]" "Secured,Non-secured"
        bitfld.long 0x00 27. "  ITS[123] ,Interrupt Secure SPI[123]" "Secured,Non-secured"
        bitfld.long 0x00 26. "  ITS[122] ,Interrupt Secure SPI[122]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 25. " ITS[121] ,Interrupt Secure SPI[121]" "Secured,Non-secured"
        bitfld.long 0x00 24. "  ITS[120] ,Interrupt Secure SPI[120]" "Secured,Non-secured"
        bitfld.long 0x00 23. "  ITS[119] ,Interrupt Secure SPI[119]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 22. " ITS[118] ,Interrupt Secure SPI[118]" "Secured,Non-secured"
        bitfld.long 0x00 21. "  ITS[117] ,Interrupt Secure SPI[117]" "Secured,Non-secured"
        bitfld.long 0x00 20. "  ITS[116] ,Interrupt Secure SPI[116]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 19. " ITS[115] ,Interrupt Secure SPI[115]" "Secured,Non-secured"
        bitfld.long 0x00 18. "  ITS[114] ,Interrupt Secure SPI[114]" "Secured,Non-secured"
        bitfld.long 0x00 17. "  ITS[113] ,Interrupt Secure SPI[113]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 16. " ITS[112] ,Interrupt Secure SPI[112]" "Secured,Non-secured"
        bitfld.long 0x00 15. "  ITS[111] ,Interrupt Secure SPI[111]" "Secured,Non-secured"
        bitfld.long 0x00 14. "  ITS[110] ,Interrupt Secure SPI[110]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 13. " ITS[109] ,Interrupt Secure SPI[109]" "Secured,Non-secured"
        bitfld.long 0x00 12. "  ITS[108] ,Interrupt Secure SPI[108]" "Secured,Non-secured"
        bitfld.long 0x00 11. "  ITS[107] ,Interrupt Secure SPI[107]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 10. " ITS[106] ,Interrupt Secure SPI[106]" "Secured,Non-secured"
        bitfld.long 0x00 9. "  ITS[105] ,Interrupt Secure SPI[105]" "Secured,Non-secured"
        bitfld.long 0x00 8. "  ITS[104] ,Interrupt Secure SPI[104]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 7. " ITS[103] ,Interrupt Secure SPI[103]" "Secured,Non-secured"
        bitfld.long 0x00 6. "  ITS[102] ,Interrupt Secure SPI[102]" "Secured,Non-secured"
        bitfld.long 0x00 5. "  ITS[101] ,Interrupt Secure SPI[101]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 4. " ITS[100] ,Interrupt Secure SPI[100]" "Secured,Non-secured"
        bitfld.long 0x00 3. "  ITS[99]  ,Interrupt Secure SPI[99]" "Secured,Non-secured"
        bitfld.long 0x00 2. "  ITS[98]  ,Interrupt Secure SPI[98]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 1. " ITS[97]  ,Interrupt Secure SPI[97]" "Secured,Non-secured"
        bitfld.long 0x00 0. "  ITS[96]  ,Interrupt Secure SPI[96]" "Secured,Non-secured"
group.long 0x94++0x03
    line.long 0x00 "ICDISR5,Interrupt Security Register[5]"    
        bitfld.long 0x00 31. " ITS[159] ,Interrupt Secure SPI[159]" "Secured,Non-secured"
        bitfld.long 0x00 30. "  ITS[158] ,Interrupt Secure SPI[158]" "Secured,Non-secured"
        bitfld.long 0x00 29. "  ITS[157] ,Interrupt Secure SPI[157]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 28. " ITS[156] ,Interrupt Secure SPI[156]" "Secured,Non-secured"
        bitfld.long 0x00 27. "  ITS[155] ,Interrupt Secure SPI[155]" "Secured,Non-secured"
        bitfld.long 0x00 26. "  ITS[154] ,Interrupt Secure SPI[154]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 25. " ITS[153] ,Interrupt Secure SPI[153]" "Secured,Non-secured"
        bitfld.long 0x00 24. "  ITS[152] ,Interrupt Secure SPI[152]" "Secured,Non-secured"
        bitfld.long 0x00 23. "  ITS[151] ,Interrupt Secure SPI[151]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 22. " ITS[150] ,Interrupt Secure SPI[150]" "Secured,Non-secured"
        bitfld.long 0x00 21. "  ITS[149] ,Interrupt Secure SPI[149]" "Secured,Non-secured"
        bitfld.long 0x00 20. "  ITS[148] ,Interrupt Secure SPI[148]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 19. " ITS[147] ,Interrupt Secure SPI[147]" "Secured,Non-secured"
        bitfld.long 0x00 18. "  ITS[146] ,Interrupt Secure SPI[146]" "Secured,Non-secured"
        bitfld.long 0x00 17. "  ITS[145] ,Interrupt Secure SPI[145]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 16. " ITS[144] ,Interrupt Secure SPI[144]" "Secured,Non-secured"
        bitfld.long 0x00 15. "  ITS[143] ,Interrupt Secure SPI[143]" "Secured,Non-secured"
        bitfld.long 0x00 14. "  ITS[142] ,Interrupt Secure SPI[142]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 13. " ITS[141] ,Interrupt Secure SPI[141]" "Secured,Non-secured"
        bitfld.long 0x00 12. "  ITS[140] ,Interrupt Secure SPI[140]" "Secured,Non-secured"
        bitfld.long 0x00 11. "  ITS[139] ,Interrupt Secure SPI[139]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 10. " ITS[138] ,Interrupt Secure SPI[138]" "Secured,Non-secured"
        bitfld.long 0x00 9. "  ITS[137] ,Interrupt Secure SPI[137]" "Secured,Non-secured"
        bitfld.long 0x00 8. "  ITS[136] ,Interrupt Secure SPI[136]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 7. " ITS[135] ,Interrupt Secure SPI[135]" "Secured,Non-secured"
        bitfld.long 0x00 6. "  ITS[134] ,Interrupt Secure SPI[134]" "Secured,Non-secured"
        bitfld.long 0x00 5. "  ITS[133] ,Interrupt Secure SPI[133]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 4. " ITS[132] ,Interrupt Secure SPI[132]" "Secured,Non-secured"
        bitfld.long 0x00 3. "  ITS[131] ,Interrupt Secure SPI[131]" "Secured,Non-secured"
        bitfld.long 0x00 2. "  ITS[130] ,Interrupt Secure SPI[130]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 1. " ITS[129] ,Interrupt Secure SPI[129]" "Secured,Non-secured"
        bitfld.long 0x00 0. "  ITS[128] ,Interrupt Secure SPI[128]" "Secured,Non-secured"
group.long 0x98++0x03
    line.long 0x00 "ICDISR6,Interrupt Security Register[6]"    
        bitfld.long 0x00 31. " ITS[191] ,Interrupt Secure SPI[191]" "Secured,Non-secured"
        bitfld.long 0x00 30. "  ITS[190] ,Interrupt Secure SPI[190]" "Secured,Non-secured"
        bitfld.long 0x00 29. "  ITS[189] ,Interrupt Secure SPI[189]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 28. " ITS[188] ,Interrupt Secure SPI[188]" "Secured,Non-secured"
        bitfld.long 0x00 27. "  ITS[187] ,Interrupt Secure SPI[187]" "Secured,Non-secured"
        bitfld.long 0x00 26. "  ITS[186] ,Interrupt Secure SPI[186]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 25. " ITS[185] ,Interrupt Secure SPI[185]" "Secured,Non-secured"
        bitfld.long 0x00 24. "  ITS[184] ,Interrupt Secure SPI[184]" "Secured,Non-secured"
        bitfld.long 0x00 23. "  ITS[183] ,Interrupt Secure SPI[183]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 22. " ITS[182] ,Interrupt Secure SPI[182]" "Secured,Non-secured"
        bitfld.long 0x00 21. "  ITS[181] ,Interrupt Secure SPI[181]" "Secured,Non-secured"
        bitfld.long 0x00 20. "  ITS[180] ,Interrupt Secure SPI[180]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 19. " ITS[179] ,Interrupt Secure SPI[179]" "Secured,Non-secured"
        bitfld.long 0x00 18. "  ITS[178] ,Interrupt Secure SPI[178]" "Secured,Non-secured"
        bitfld.long 0x00 17. "  ITS[177] ,Interrupt Secure SPI[177]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 16. " ITS[176] ,Interrupt Secure SPI[176]" "Secured,Non-secured"
        bitfld.long 0x00 15. "  ITS[175] ,Interrupt Secure SPI[175]" "Secured,Non-secured"
        bitfld.long 0x00 14. "  ITS[174] ,Interrupt Secure SPI[174]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 13. " ITS[173] ,Interrupt Secure SPI[173]" "Secured,Non-secured"
        bitfld.long 0x00 12. "  ITS[172] ,Interrupt Secure SPI[172]" "Secured,Non-secured"
        bitfld.long 0x00 11. "  ITS[171] ,Interrupt Secure SPI[171]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 10. " ITS[170] ,Interrupt Secure SPI[170]" "Secured,Non-secured"
        bitfld.long 0x00 9. "  ITS[169] ,Interrupt Secure SPI[169]" "Secured,Non-secured"
        bitfld.long 0x00 8. "  ITS[168] ,Interrupt Secure SPI[168]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 7. " ITS[167] ,Interrupt Secure SPI[167]" "Secured,Non-secured"
        bitfld.long 0x00 6. "  ITS[166] ,Interrupt Secure SPI[166]" "Secured,Non-secured"
        bitfld.long 0x00 5. "  ITS[165] ,Interrupt Secure SPI[165]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 4. " ITS[164] ,Interrupt Secure SPI[164]" "Secured,Non-secured"
        bitfld.long 0x00 3. "  ITS[163] ,Interrupt Secure SPI[163]" "Secured,Non-secured"
        bitfld.long 0x00 2. "  ITS[162] ,Interrupt Secure SPI[162]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 1. " ITS[161] ,Interrupt Secure SPI[161]" "Secured,Non-secured"
        bitfld.long 0x00 0. "  ITS[160] ,Interrupt Secure SPI[160]" "Secured,Non-secured"
group.long 0x9c++0x03
    line.long 0x00 "ICDISR7,Interrupt Security Register[7]"    
        bitfld.long 0x00 31. " ITS[223] ,Interrupt Secure SPI[223]" "Secured,Non-secured"
        bitfld.long 0x00 30. "  ITS[222] ,Interrupt Secure SPI[222]" "Secured,Non-secured"
        bitfld.long 0x00 29. "  ITS[221] ,Interrupt Secure SPI[221]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 28. " ITS[220] ,Interrupt Secure SPI[220]" "Secured,Non-secured"
        bitfld.long 0x00 27. "  ITS[219] ,Interrupt Secure SPI[219]" "Secured,Non-secured"
        bitfld.long 0x00 26. "  ITS[218] ,Interrupt Secure SPI[218]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 25. " ITS[217] ,Interrupt Secure SPI[217]" "Secured,Non-secured"
        bitfld.long 0x00 24. "  ITS[216] ,Interrupt Secure SPI[216]" "Secured,Non-secured"
        bitfld.long 0x00 23. "  ITS[215] ,Interrupt Secure SPI[215]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 22. " ITS[214] ,Interrupt Secure SPI[214]" "Secured,Non-secured"
        bitfld.long 0x00 21. "  ITS[213] ,Interrupt Secure SPI[213]" "Secured,Non-secured"
        bitfld.long 0x00 20. "  ITS[212] ,Interrupt Secure SPI[212]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 19. " ITS[211] ,Interrupt Secure SPI[211]" "Secured,Non-secured"
        bitfld.long 0x00 18. "  ITS[210] ,Interrupt Secure SPI[210]" "Secured,Non-secured"
        bitfld.long 0x00 17. "  ITS[209] ,Interrupt Secure SPI[209]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 16. " ITS[208] ,Interrupt Secure SPI[208]" "Secured,Non-secured"
        bitfld.long 0x00 15. "  ITS[207] ,Interrupt Secure SPI[207]" "Secured,Non-secured"
        bitfld.long 0x00 14. "  ITS[206] ,Interrupt Secure SPI[206]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 13. " ITS[205] ,Interrupt Secure SPI[205]" "Secured,Non-secured"
        bitfld.long 0x00 12. "  ITS[204] ,Interrupt Secure SPI[204]" "Secured,Non-secured"
        bitfld.long 0x00 11. "  ITS[203] ,Interrupt Secure SPI[203]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 10. " ITS[202] ,Interrupt Secure SPI[202]" "Secured,Non-secured"
        bitfld.long 0x00 9. "  ITS[201] ,Interrupt Secure SPI[201]" "Secured,Non-secured"
        bitfld.long 0x00 8. "  ITS[200] ,Interrupt Secure SPI[200]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 7. " ITS[199] ,Interrupt Secure SPI[199]" "Secured,Non-secured"
        bitfld.long 0x00 6. "  ITS[198] ,Interrupt Secure SPI[198]" "Secured,Non-secured"
        bitfld.long 0x00 5. "  ITS[197] ,Interrupt Secure SPI[197]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 4. " ITS[196] ,Interrupt Secure SPI[196]" "Secured,Non-secured"
        bitfld.long 0x00 3. "  ITS[195] ,Interrupt Secure SPI[195]" "Secured,Non-secured"
        bitfld.long 0x00 2. "  ITS[194] ,Interrupt Secure SPI[194]" "Secured,Non-secured"
        textline "                  "
        bitfld.long 0x00 1. " ITS[193] ,Interrupt Secure SPI[193]" "Secured,Non-secured"
        bitfld.long 0x00 0. "  ITS[192] ,Interrupt Secure SPI[192]" "Secured,Non-secured"    
tree.end
width 10.        
tree "Interrupt Set-Enable Registers"
group.long 0x100++0x03
    line.long 0x00 "ICDISER0,Interrupt Set-Enable Register 0"
        bitfld.long 0x00 31. " ISETP[3]  ,Interrupt PPI[3] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISETP[2]  ,Interrupt PPI[2] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISETP[1]  ,Interrupt PPI[1] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 28. " ISETP[0]  ,Interrupt PPI[0] Set" "No effect,Set"
        bitfld.long 0x00 15. "  ISETS[15] ,Interrupt SBO[15] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISETS[14] ,Interrupt SBO[14] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 13. " ISETS[13] ,Interrupt SBO[13] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISETS[12] ,Interrupt SBO[12] Set" "No effect,Set"
        bitfld.long 0x00 11. "  ISETS[11] ,Interrupt SBO[11] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 10. " ISETS[10] ,Interrupt SBO[10] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISETS[9]  ,Interrupt SBO[9] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISETS[8]  ,Interrupt SBO[8] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 7. " ISETS[7]  ,Interrupt SBO[7] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISETS[6]  ,Interrupt SBO[6] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISETS[5]  ,Interrupt SBO[5] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 4. " ISETS[4]  ,Interrupt SBO[4] Set" "No effect,Set"
        bitfld.long 0x00 3. "  ISETS[3]  ,Interrupt SBO[3] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISETS[2]  ,Interrupt SBO[2] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 1. " ISETS[1]  ,Interrupt SBO[1] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISETS[0]  ,Interrupt SBO[0] Set" "No effect,Set"
group.long 0x104++0x03
    line.long 0x00 "ICDISER1,Interrupt Set-Enable Register 1"        
        bitfld.long 0x00 31. " ISET[31]  ,Interrupt SPI[31] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISET[30]  ,Interrupt SPI[30] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISET[29]  ,Interrupt SPI[29] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 28. " ISET[28]  ,Interrupt SPI[28] Set" "No effect,Set"
        bitfld.long 0x00 27. "  ISET[27]  ,Interrupt SPI[27] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISET[26]  ,Interrupt SPI[26] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 25. " ISET[25]  ,Interrupt SPI[25] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISET[24]  ,Interrupt SPI[24] Set" "No effect,Set"
        bitfld.long 0x00 23. "  ISET[23]  ,Interrupt SPI[23] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 22. " ISET[22]  ,Interrupt SPI[22] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISET[21]  ,Interrupt SPI[21] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISET[20]  ,Interrupt SPI[20] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 19. " ISET[19]  ,Interrupt SPI[19] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISET[18]  ,Interrupt SPI[18] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISET[17]  ,Interrupt SPI[17] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 16. " ISET[16]  ,Interrupt SPI[16] Set" "No effect,Set"
        bitfld.long 0x00 15. "  ISET[15]  ,Interrupt SPI[15] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISET[14]  ,Interrupt SPI[14] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 13. " ISET[13]  ,Interrupt SPI[13] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISET[12]  ,Interrupt SPI[12] Set" "No effect,Set"
        bitfld.long 0x00 11. "  ISET[11]  ,Interrupt SPI[11] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 10. " ISET[10]  ,Interrupt SPI[10] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISET[9]   ,Interrupt SPI[9] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISET[8]   ,Interrupt SPI[8] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 7. " ISET[7]   ,Interrupt SPI[7] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISET[6]   ,Interrupt SPI[6] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISET[5]   ,Interrupt SPI[5] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 4. " ISET[4]   ,Interrupt SPI[4] Set" "No effect,Set"
        bitfld.long 0x00 3. "  ISET[3]   ,Interrupt SPI[3] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISET[2]   ,Interrupt SPI[2] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 1. " ISET[1]   ,Interrupt SPI[1] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISET[0]   ,Interrupt SPI[0] Set" "No effect,Set"        
group.long 0x108++0x03
    line.long 0x00 "ICDISER2,Interrupt Set-Enable Register 2"
        bitfld.long 0x00 31. " ISET[63]  ,Interrupt SPI[63] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISET[62]  ,Interrupt SPI[62] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISET[61]  ,Interrupt SPI[61] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 28. " ISET[60]  ,Interrupt SPI[60] Set" "No effect,Set"
        bitfld.long 0x00 27. "  ISET[59]  ,Interrupt SPI[59] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISET[58]  ,Interrupt SPI[58] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 25. " ISET[57]  ,Interrupt SPI[57] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISET[56]  ,Interrupt SPI[56] Set" "No effect,Set"
        bitfld.long 0x00 23. "  ISET[55]  ,Interrupt SPI[55] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 22. " ISET[54]  ,Interrupt SPI[54] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISET[53]  ,Interrupt SPI[53] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISET[52]  ,Interrupt SPI[52] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 19. " ISET[51]  ,Interrupt SPI[51] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISET[50]  ,Interrupt SPI[50] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISET[49]  ,Interrupt SPI[49] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 16. " ISET[48]  ,Interrupt SPI[48] Set" "No effect,Set"
        bitfld.long 0x00 15. "  ISET[47]  ,Interrupt SPI[47] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISET[46]  ,Interrupt SPI[46] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 13. " ISET[45]  ,Interrupt SPI[45] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISET[44]  ,Interrupt SPI[44] Set" "No effect,Set"
        bitfld.long 0x00 11. "  ISET[43]  ,Interrupt SPI[43] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 10. " ISET[42]  ,Interrupt SPI[42] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISET[41]  ,Interrupt SPI[41] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISET[40]  ,Interrupt SPI[40] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 7. " ISET[39]  ,Interrupt SPI[39] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISET[38]  ,Interrupt SPI[38] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISET[37]  ,Interrupt SPI[37] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 4. " ISET[36]  ,Interrupt SPI[36] Set" "No effect,Set"
        bitfld.long 0x00 3. "  ISET[35]  ,Interrupt SPI[35] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISET[34]  ,Interrupt SPI[34] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 1. " ISET[33]  ,Interrupt SPI[33] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISET[32]  ,Interrupt SPI[32] Set" "No effect,Set"
group.long 0x10c++0x03
    line.long 0x00 "ICDISER3,Interrupt Set-Enable Register 3"    
        bitfld.long 0x00 31. " ISET[95]  ,Interrupt SPI[95] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISET[94]  ,Interrupt SPI[94] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISET[93]  ,Interrupt SPI[93] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 28. " ISET[92]  ,Interrupt SPI[92] Set" "No effect,Set"
        bitfld.long 0x00 27. "  ISET[91]  ,Interrupt SPI[91] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISET[90]  ,Interrupt SPI[90] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 25. " ISET[89]  ,Interrupt SPI[89] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISET[88]  ,Interrupt SPI[88] Set" "No effect,Set"
        bitfld.long 0x00 23. "  ISET[87]  ,Interrupt SPI[87] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 22. " ISET[86]  ,Interrupt SPI[86] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISET[85]  ,Interrupt SPI[85] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISET[84]  ,Interrupt SPI[84] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 19. " ISET[83]  ,Interrupt SPI[83] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISET[82]  ,Interrupt SPI[82] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISET[81]  ,Interrupt SPI[81] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 16. " ISET[80]  ,Interrupt SPI[80] Set" "No effect,Set"
        bitfld.long 0x00 15. "  ISET[79]  ,Interrupt SPI[79] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISET[78]  ,Interrupt SPI[78] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 13. " ISET[77]  ,Interrupt SPI[77] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISET[76]  ,Interrupt SPI[76] Set" "No effect,Set"
        bitfld.long 0x00 11. "  ISET[75]  ,Interrupt SPI[75] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 10. " ISET[74]  ,Interrupt SPI[74] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISET[73]  ,Interrupt SPI[73] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISET[72]  ,Interrupt SPI[72] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 7. " ISET[71]  ,Interrupt SPI[71] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISET[70]  ,Interrupt SPI[70] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISET[69]  ,Interrupt SPI[69] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 4. " ISET[68]  ,Interrupt SPI[68] Set" "No effect,Set"
        bitfld.long 0x00 3. "  ISET[67]  ,Interrupt SPI[67] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISET[66]  ,Interrupt SPI[66] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 1. " ISET[65]  ,Interrupt SPI[65] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISET[64]  ,Interrupt SPI[64] Set" "No effect,Set"
group.long 0x110++0x03
    line.long 0x00 "ICDISER4,Interrupt Set-Enable Register 4"
        bitfld.long 0x00 31. " ISET[127] ,Interrupt SPI[127] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISET[126] ,Interrupt SPI[126] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISET[125] ,Interrupt SPI[125] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 28. " ISET[124] ,Interrupt SPI[124] Set" "No effect,Set"
        bitfld.long 0x00 27. "  ISET[123] ,Interrupt SPI[123] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISET[122] ,Interrupt SPI[122] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 25. " ISET[121] ,Interrupt SPI[121] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISET[120] ,Interrupt SPI[120] Set" "No effect,Set"
        bitfld.long 0x00 23. "  ISET[119] ,Interrupt SPI[119] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 22. " ISET[118] ,Interrupt SPI[118] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISET[117] ,Interrupt SPI[117] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISET[116] ,Interrupt SPI[116] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 19. " ISET[115] ,Interrupt SPI[115] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISET[114] ,Interrupt SPI[114] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISET[113] ,Interrupt SPI[113] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 16. " ISET[112] ,Interrupt SPI[112] Set" "No effect,Set"
        bitfld.long 0x00 15. "  ISET[111] ,Interrupt SPI[111] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISET[110] ,Interrupt SPI[110] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 13. " ISET[109] ,Interrupt SPI[109] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISET[108] ,Interrupt SPI[108] Set" "No effect,Set"
        bitfld.long 0x00 11. "  ISET[107] ,Interrupt SPI[107] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 10. " ISET[106] ,Interrupt SPI[106] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISET[105] ,Interrupt SPI[105] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISET[104] ,Interrupt SPI[104] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 7. " ISET[103] ,Interrupt SPI[103] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISET[102] ,Interrupt SPI[102] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISET[101] ,Interrupt SPI[101] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 4. " ISET[100] ,Interrupt SPI[100] Set" "No effect,Set"
        bitfld.long 0x00 3. "  ISET[99]  ,Interrupt SPI[99] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISET[98]  ,Interrupt SPI[98] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 1. " ISET[97]  ,Interrupt SPI[97] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISET[96]  ,Interrupt SPI[96] Set" "No effect,Set"
group.long 0x114++0x03
    line.long 0x00 "ICDISER5,Interrupt Set-Enable Register 5"    
        bitfld.long 0x00 31. " ISET[159] ,Interrupt SPI[159] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISET[158] ,Interrupt SPI[158] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISET[157] ,Interrupt SPI[157] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 28. " ISET[156] ,Interrupt SPI[156] Set" "No effect,Set"
        bitfld.long 0x00 27. "  ISET[155] ,Interrupt SPI[155] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISET[154] ,Interrupt SPI[154] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 25. " ISET[153] ,Interrupt SPI[153] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISET[152] ,Interrupt SPI[152] Set" "No effect,Set"
        bitfld.long 0x00 23. "  ISET[151] ,Interrupt SPI[151] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 22. " ISET[150] ,Interrupt SPI[150] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISET[149] ,Interrupt SPI[149] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISET[148] ,Interrupt SPI[148] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 19. " ISET[147] ,Interrupt SPI[147] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISET[146] ,Interrupt SPI[146] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISET[145] ,Interrupt SPI[145] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 16. " ISET[144] ,Interrupt SPI[144] Set" "No effect,Set"
        bitfld.long 0x00 15. "  ISET[143] ,Interrupt SPI[143] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISET[142] ,Interrupt SPI[142] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 13. " ISET[141] ,Interrupt SPI[141] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISET[140] ,Interrupt SPI[140] Set" "No effect,Set"
        bitfld.long 0x00 11. "  ISET[139] ,Interrupt SPI[139] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 10. " ISET[138] ,Interrupt SPI[138] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISET[137] ,Interrupt SPI[137] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISET[136] ,Interrupt SPI[136] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 7. " ISET[135] ,Interrupt SPI[135] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISET[134] ,Interrupt SPI[134] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISET[133] ,Interrupt SPI[133] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 4. " ISET[132] ,Interrupt SPI[132] Set" "No effect,Set"
        bitfld.long 0x00 3. "  ISET[131] ,Interrupt SPI[131] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISET[130] ,Interrupt SPI[130] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 1. " ISET[129] ,Interrupt SPI[129] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISET[128] ,Interrupt SPI[128] Set" "No effect,Set"
group.long 0x118++0x03
    line.long 0x00 "ICDISER6,Interrupt Set-Enable Register 6"        
        bitfld.long 0x00 31. " ISET[191] ,Interrupt SPI[191] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISET[190] ,Interrupt SPI[190] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISET[189] ,Interrupt SPI[189] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 28. " ISET[188] ,Interrupt SPI[188] Set" "No effect,Set"
        bitfld.long 0x00 27. "  ISET[187] ,Interrupt SPI[187] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISET[186] ,Interrupt SPI[186] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 25. " ISET[185] ,Interrupt SPI[185] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISET[184] ,Interrupt SPI[184] Set" "No effect,Set"
        bitfld.long 0x00 23. "  ISET[183] ,Interrupt SPI[183] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 22. " ISET[182] ,Interrupt SPI[182] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISET[181] ,Interrupt SPI[181] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISET[180] ,Interrupt SPI[180] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 19. " ISET[179] ,Interrupt SPI[179] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISET[178] ,Interrupt SPI[178] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISET[177] ,Interrupt SPI[177] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 16. " ISET[176] ,Interrupt SPI[176] Set" "No effect,Set"
        bitfld.long 0x00 15. "  ISET[175] ,Interrupt SPI[175] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISET[174] ,Interrupt SPI[174] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 13. " ISET[173] ,Interrupt SPI[173] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISET[172] ,Interrupt SPI[172] Set" "No effect,Set"
        bitfld.long 0x00 11. "  ISET[171] ,Interrupt SPI[171] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 10. " ISET[170] ,Interrupt SPI[170] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISET[169] ,Interrupt SPI[169] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISET[168] ,Interrupt SPI[168] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 7. " ISET[167] ,Interrupt SPI[167] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISET[166] ,Interrupt SPI[166] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISET[165] ,Interrupt SPI[165] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 4. " ISET[164] ,Interrupt SPI[164] Set" "No effect,Set"
        bitfld.long 0x00 3. "  ISET[163] ,Interrupt SPI[163] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISET[162] ,Interrupt SPI[162] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 1. " ISET[161] ,Interrupt SPI[161] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISET[160] ,Interrupt SPI[160] Set" "No effect,Set"
group.long 0x11c++0x03
    line.long 0x00 "ICDISER7,Interrupt Set-Enable Register 7"        
        bitfld.long 0x00 31. " ISET[223] ,Interrupt SPI[223] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISET[222] ,Interrupt SPI[222] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISET[221] ,Interrupt SPI[221] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 28. " ISET[220] ,Interrupt SPI[220] Set" "No effect,Set"
        bitfld.long 0x00 27. "  ISET[219] ,Interrupt SPI[219] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISET[218] ,Interrupt SPI[218] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 25. " ISET[217] ,Interrupt SPI[217] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISET[216] ,Interrupt SPI[216] Set" "No effect,Set"
        bitfld.long 0x00 23. "  ISET[215] ,Interrupt SPI[215] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 22. " ISET[214] ,Interrupt SPI[214] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISET[213] ,Interrupt SPI[213] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISET[212] ,Interrupt SPI[212] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 19. " ISET[211] ,Interrupt SPI[211] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISET[210] ,Interrupt SPI[210] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISET[209] ,Interrupt SPI[209] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 16. " ISET[208] ,Interrupt SPI[208] Set" "No effect,Set"
        bitfld.long 0x00 15. "  ISET[207] ,Interrupt SPI[207] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISET[206] ,Interrupt SPI[206] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 13. " ISET[205] ,Interrupt SPI[205] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISET[204] ,Interrupt SPI[204] Set" "No effect,Set"
        bitfld.long 0x00 11. "  ISET[203] ,Interrupt SPI[203] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 10. " ISET[202] ,Interrupt SPI[202] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISET[201] ,Interrupt SPI[201] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISET[200] ,Interrupt SPI[200] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 7. " ISET[199] ,Interrupt SPI[199] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISET[198] ,Interrupt SPI[198] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISET[197] ,Interrupt SPI[197] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 4. " ISET[196] ,Interrupt SPI[196] Set" "No effect,Set"
        bitfld.long 0x00 3. "  ISET[195] ,Interrupt SPI[195] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISET[194] ,Interrupt SPI[194] Set" "No effect,Set"
        textline "                   "
        bitfld.long 0x00 1. " ISET[193] ,Interrupt SPI[193] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISET[192] ,Interrupt SPI[192] Set" "No effect,Set"    
tree.end
width 10.
tree "Interrupt Clear-Enable Registers"
group.long 0x180++0x03
    line.long 0x00 "ICDICER0,Interrupt Clear-Enable Register 0"
        bitfld.long 0x00 31. " ICLRP[3]  ,Interrupt PPI[3] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICLRP[2]  ,Interrupt PPI[2] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICLRP[1]  ,Interrupt PPI[1] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 28. " ICLRP[0]  ,Interrupt PPI[0] Clear" "No effect,Cleared"
        bitfld.long 0x00 15. "  ICLRS[15] ,Interrupt STI[15] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICLRS[14] ,Interrupt STI[14] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 13. " ICLRS[13] ,Interrupt STI[13] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICLRS[12] ,Interrupt STI[12] Clear" "No effect,Cleared"
        bitfld.long 0x00 11. "  ICLRS[11] ,Interrupt STI[11] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 10. " ICLRS[10] ,Interrupt STI[10] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICLRS[9]  ,Interrupt STI[9] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICLRS[8]  ,Interrupt STI[8] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICLRS[7]  ,Interrupt STI[7] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICLRS[6]  ,Interrupt STI[6] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICLRS[5]  ,Interrupt STI[5] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 4. " ICLRS[4]  ,Interrupt STI[4] Clear" "No effect,Cleared"
        bitfld.long 0x00 3. "  ICLRS[3]  ,Interrupt STI[3] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICLRS[2]  ,Interrupt STI[2] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 1. " ICLR[1]   ,Interrupt STI[1] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICLR[0]   ,Interrupt STI[0] Clear" "No effect,Cleared"
group.long 0x184++0x03
    line.long 0x00 "ICDICER1,Interrupt Clear-Enable Register 1"        
        bitfld.long 0x00 31. " ICLR[31]  ,Interrupt SPI[31] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICLR[30]  ,Interrupt SPI[30] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICLR[29]  ,Interrupt SPI[29] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 28. " ICLR[28]  ,Interrupt SPI[28] Clear" "No effect,Cleared"
        bitfld.long 0x00 27. "  ICLR[27]  ,Interrupt SPI[27] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICLR[26]  ,Interrupt SPI[26] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 25. " ICLR[25]  ,Interrupt SPI[25] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICLR[24]  ,Interrupt SPI[24] Clear" "No effect,Cleared"
        bitfld.long 0x00 23. "  ICLR[23]  ,Interrupt SPI[23] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 22. " ICLR[22]  ,Interrupt SPI[22] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICLR[21]  ,Interrupt SPI[21] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICLR[20]  ,Interrupt SPI[20] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICLR[19]  ,Interrupt SPI[19] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICLR[18]  ,Interrupt SPI[18] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICLR[17]  ,Interrupt SPI[17] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 16. " ICLR[16]  ,Interrupt SPI[16] Clear" "No effect,Cleared"
        bitfld.long 0x00 15. "  ICLR[15]  ,Interrupt SPI[15] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICLR[14]  ,Interrupt SPI[14] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 13. " ICLR[13]  ,Interrupt SPI[13] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICLR[12]  ,Interrupt SPI[12] Clear" "No effect,Cleared"
        bitfld.long 0x00 11. "  ICLR[11]  ,Interrupt SPI[11] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 10. " ICLR[10]  ,Interrupt SPI[10] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICLR[9]   ,Interrupt SPI[9] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICLR[8]   ,Interrupt SPI[8] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICLR[7]   ,Interrupt SPI[7] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICLR[6]   ,Interrupt SPI[6] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICLR[5]   ,Interrupt SPI[5] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 4. " ICLR[4]   ,Interrupt SPI[4] Clear" "No effect,Cleared"
        bitfld.long 0x00 3. "  ICLR[3]   ,Interrupt SPI[3] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICLR[2]   ,Interrupt SPI[2] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 1. " ICLR[1]   ,Interrupt SPI[1] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICLR[0]   ,Interrupt SPI[0] Clear" "No effect,Cleared"        
group.long 0x188++0x03
    line.long 0x00 "ICDICER2,Interrupt Clear-Enable Register 2"
        bitfld.long 0x00 31. " ICLR[63]  ,Interrupt SPI[63] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICLR[62]  ,Interrupt SPI[62] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICLR[61]  ,Interrupt SPI[61] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 28. " ICLR[60]  ,Interrupt SPI[60] Clear" "No effect,Cleared"
        bitfld.long 0x00 27. "  ICLR[59]  ,Interrupt SPI[59] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICLR[58]  ,Interrupt SPI[58] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 25. " ICLR[57]  ,Interrupt SPI[57] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICLR[56]  ,Interrupt SPI[56] Clear" "No effect,Cleared"
        bitfld.long 0x00 23. "  ICLR[55]  ,Interrupt SPI[55] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 22. " ICLR[54]  ,Interrupt SPI[54] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICLR[53]  ,Interrupt SPI[53] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICLR[52]  ,Interrupt SPI[52] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICLR[51]  ,Interrupt SPI[51] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICLR[50]  ,Interrupt SPI[50] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICLR[49]  ,Interrupt SPI[49] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 16. " ICLR[48]  ,Interrupt SPI[48] Clear" "No effect,Cleared"
        bitfld.long 0x00 15. "  ICLR[47]  ,Interrupt SPI[47] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICLR[46]  ,Interrupt SPI[46] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 13. " ICLR[45]  ,Interrupt SPI[45] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICLR[44]  ,Interrupt SPI[44] Clear" "No effect,Cleared"
        bitfld.long 0x00 11. "  ICLR[43]  ,Interrupt SPI[43] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 10. " ICLR[42]  ,Interrupt SPI[42] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICLR[41]  ,Interrupt SPI[41] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICLR[40]  ,Interrupt SPI[40] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICLR[39]  ,Interrupt SPI[39] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICLR[38]  ,Interrupt SPI[38] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICLR[37]  ,Interrupt SPI[37] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 4. " ICLR[36]  ,Interrupt SPI[36] Clear" "No effect,Cleared"
        bitfld.long 0x00 3. "  ICLR[35]  ,Interrupt SPI[35] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICLR[34]  ,Interrupt SPI[34] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 1. " ICLR[33]  ,Interrupt SPI[33] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICLR[32]  ,Interrupt SPI[32] Clear" "No effect,Cleared"
group.long 0x18c++0x03
    line.long 0x00 "ICDICER3,Interrupt Clear-Enable Register 3"    
        bitfld.long 0x00 31. " ICLR[95]  ,Interrupt SPI[95] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICLR[94]  ,Interrupt SPI[94] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICLR[93]  ,Interrupt SPI[93] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 28. " ICLR[92]  ,Interrupt SPI[92] Clear" "No effect,Cleared"
        bitfld.long 0x00 27. "  ICLR[91]  ,Interrupt SPI[91] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICLR[90]  ,Interrupt SPI[90] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 25. " ICLR[89]  ,Interrupt SPI[89] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICLR[88]  ,Interrupt SPI[88] Clear" "No effect,Cleared"
        bitfld.long 0x00 23. "  ICLR[87]  ,Interrupt SPI[87] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 22. " ICLR[86]  ,Interrupt SPI[86] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICLR[85]  ,Interrupt SPI[85] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICLR[84]  ,Interrupt SPI[84] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICLR[83]  ,Interrupt SPI[83] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICLR[82]  ,Interrupt SPI[82] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICLR[81]  ,Interrupt SPI[81] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 16. " ICLR[80]  ,Interrupt SPI[80] Clear" "No effect,Cleared"
        bitfld.long 0x00 15. "  ICLR[79]  ,Interrupt SPI[79] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICLR[78]  ,Interrupt SPI[78] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 13. " ICLR[77]  ,Interrupt SPI[77] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICLR[76]  ,Interrupt SPI[76] Clear" "No effect,Cleared"
        bitfld.long 0x00 11. "  ICLR[75]  ,Interrupt SPI[75] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 10. " ICLR[74]  ,Interrupt SPI[74] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICLR[73]  ,Interrupt SPI[73] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICLR[72]  ,Interrupt SPI[72] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICLR[71]  ,Interrupt SPI[71] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICLR[70]  ,Interrupt SPI[70] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICLR[69]  ,Interrupt SPI[69] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 4. " ICLR[68]  ,Interrupt SPI[68] Clear" "No effect,Cleared"
        bitfld.long 0x00 3. "  ICLR[67]  ,Interrupt SPI[67] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICLR[66]  ,Interrupt SPI[66] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 1. " ICLR[65]  ,Interrupt SPI[65] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICLR[64]  ,Interrupt SPI[64] Clear" "No effect,Cleared"
group.long 0x190++0x03
    line.long 0x00 "ICDICER4,Interrupt Clear-Enable Register 4"
        bitfld.long 0x00 31. " ICLR[127] ,Interrupt SPI[127] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICLR[126] ,Interrupt SPI[126] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICLR[125] ,Interrupt SPI[125] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 28. " ICLR[124] ,Interrupt SPI[124] Clear" "No effect,Cleared"
        bitfld.long 0x00 27. "  ICLR[123] ,Interrupt SPI[123] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICLR[122] ,Interrupt SPI[122] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 25. " ICLR[121] ,Interrupt SPI[121] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICLR[120] ,Interrupt SPI[120] Clear" "No effect,Cleared"
        bitfld.long 0x00 23. "  ICLR[119] ,Interrupt SPI[119] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 22. " ICLR[118] ,Interrupt SPI[118] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICLR[117] ,Interrupt SPI[117] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICLR[116] ,Interrupt SPI[116] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICLR[115] ,Interrupt SPI[115] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICLR[114] ,Interrupt SPI[114] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICLR[113] ,Interrupt SPI[113] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 16. " ICLR[112] ,Interrupt SPI[112] Clear" "No effect,Cleared"
        bitfld.long 0x00 15. "  ICLR[111] ,Interrupt SPI[111] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICLR[110] ,Interrupt SPI[110] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 13. " ICLR[109] ,Interrupt SPI[109] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICLR[108] ,Interrupt SPI[108] Clear" "No effect,Cleared"
        bitfld.long 0x00 11. "  ICLR[107] ,Interrupt SPI[107] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 10. " ICLR[106] ,Interrupt SPI[106] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICLR[105] ,Interrupt SPI[105] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICLR[104] ,Interrupt SPI[104] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICLR[103] ,Interrupt SPI[103] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICLR[102] ,Interrupt SPI[102] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICLR[101] ,Interrupt SPI[101] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 4. " ICLR[100] ,Interrupt SPI[100] Clear" "No effect,Cleared"
        bitfld.long 0x00 3. "  ICLR[99]  ,Interrupt SPI[99] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICLR[98]  ,Interrupt SPI[98] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 1. " ICLR[97]  ,Interrupt SPI[97] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICLR[96]  ,Interrupt SPI[96] Clear" "No effect,Cleared"
group.long 0x194++0x03
    line.long 0x00 "ICDICER5,Interrupt Clear-Enable Register 5"    
        bitfld.long 0x00 31. " ICLR[159] ,Interrupt SPI[159] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICLR[158] ,Interrupt SPI[158] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICLR[157] ,Interrupt SPI[157] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 28. " ICLR[156] ,Interrupt SPI[156] Clear" "No effect,Cleared"
        bitfld.long 0x00 27. "  ICLR[155] ,Interrupt SPI[155] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICLR[154] ,Interrupt SPI[154] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 25. " ICLR[153] ,Interrupt SPI[153] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICLR[152] ,Interrupt SPI[152] Clear" "No effect,Cleared"
        bitfld.long 0x00 23. "  ICLR[151] ,Interrupt SPI[151] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 22. " ICLR[150] ,Interrupt SPI[150] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICLR[149] ,Interrupt SPI[149] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICLR[148] ,Interrupt SPI[148] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICLR[147] ,Interrupt SPI[147] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICLR[146] ,Interrupt SPI[146] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICLR[145] ,Interrupt SPI[145] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 16. " ICLR[144] ,Interrupt SPI[144] Clear" "No effect,Cleared"
        bitfld.long 0x00 15. "  ICLR[143] ,Interrupt SPI[143] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICLR[142] ,Interrupt SPI[142] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 13. " ICLR[141] ,Interrupt SPI[141] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICLR[140] ,Interrupt SPI[140] Clear" "No effect,Cleared"
        bitfld.long 0x00 11. "  ICLR[139] ,Interrupt SPI[139] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 10. " ICLR[138] ,Interrupt SPI[138] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICLR[137] ,Interrupt SPI[137] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICLR[136] ,Interrupt SPI[136] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICLR[135] ,Interrupt SPI[135] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICLR[134] ,Interrupt SPI[134] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICLR[133] ,Interrupt SPI[133] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 4. " ICLR[132] ,Interrupt SPI[132] Clear" "No effect,Cleared"
        bitfld.long 0x00 3. "  ICLR[131] ,Interrupt SPI[131] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICLR[130] ,Interrupt SPI[130] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 1. " ICLR[129] ,Interrupt SPI[129] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICLR[128] ,Interrupt SPI[128] Clear" "No effect,Cleared"
group.long 0x198++0x03
    line.long 0x00 "ICDICER6,Interrupt Clear-Enable Register 6"        
        bitfld.long 0x00 31. " ICLR[191] ,Interrupt SPI[191] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICLR[190] ,Interrupt SPI[190] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICLR[189] ,Interrupt SPI[189] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 28. " ICLR[188] ,Interrupt SPI[188] Clear" "No effect,Cleared"
        bitfld.long 0x00 27. "  ICLR[187] ,Interrupt SPI[187] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICLR[186] ,Interrupt SPI[186] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 25. " ICLR[185] ,Interrupt SPI[185] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICLR[184] ,Interrupt SPI[184] Clear" "No effect,Cleared"
        bitfld.long 0x00 23. "  ICLR[183] ,Interrupt SPI[183] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 22. " ICLR[182] ,Interrupt SPI[182] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICLR[181] ,Interrupt SPI[181] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICLR[180] ,Interrupt SPI[180] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICLR[179] ,Interrupt SPI[179] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICLR[178] ,Interrupt SPI[178] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICLR[177] ,Interrupt SPI[177] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 16. " ICLR[176] ,Interrupt SPI[176] Clear" "No effect,Cleared"
        bitfld.long 0x00 15. "  ICLR[175] ,Interrupt SPI[175] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICLR[174] ,Interrupt SPI[174] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 13. " ICLR[173] ,Interrupt SPI[173] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICLR[172] ,Interrupt SPI[172] Clear" "No effect,Cleared"
        bitfld.long 0x00 11. "  ICLR[171] ,Interrupt SPI[171] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 10. " ICLR[170] ,Interrupt SPI[170] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICLR[169] ,Interrupt SPI[169] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICLR[168] ,Interrupt SPI[168] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICLR[167] ,Interrupt SPI[167] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICLR[166] ,Interrupt SPI[166] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICLR[165] ,Interrupt SPI[165] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 4. " ICLR[164] ,Interrupt SPI[164] Clear" "No effect,Cleared"
        bitfld.long 0x00 3. "  ICLR[163] ,Interrupt SPI[163] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICLR[162] ,Interrupt SPI[162] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 1. " ICLR[161] ,Interrupt SPI[161] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICLR[160] ,Interrupt SPI[160] Clear" "No effect,Cleared"
group.long 0x19c++0x03
    line.long 0x00 "ICDICER7,Interrupt Clear-Enable Register 7"        
        bitfld.long 0x00 31. " ICLR[223] ,Interrupt SPI[223] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICLR[222] ,Interrupt SPI[222] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICLR[221] ,Interrupt SPI[221] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 28. " ICLR[220] ,Interrupt SPI[220] Clear" "No effect,Cleared"
        bitfld.long 0x00 27. "  ICLR[219] ,Interrupt SPI[219] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICLR[218] ,Interrupt SPI[218] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 25. " ICLR[217] ,Interrupt SPI[217] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICLR[216] ,Interrupt SPI[216] Clear" "No effect,Cleared"
        bitfld.long 0x00 23. "  ICLR[215] ,Interrupt SPI[215] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 22. " ICLR[214] ,Interrupt SPI[214] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICLR[213] ,Interrupt SPI[213] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICLR[212] ,Interrupt SPI[212] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICLR[211] ,Interrupt SPI[211] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICLR[210] ,Interrupt SPI[210] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICLR[209] ,Interrupt SPI[209] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 16. " ICLR[208] ,Interrupt SPI[208] Clear" "No effect,Cleared"
        bitfld.long 0x00 15. "  ICLR[207] ,Interrupt SPI[207] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICLR[206] ,Interrupt SPI[206] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 13. " ICLR[205] ,Interrupt SPI[205] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICLR[204] ,Interrupt SPI[204] Clear" "No effect,Cleared"
        bitfld.long 0x00 11. "  ICLR[203] ,Interrupt SPI[203] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 10. " ICLR[202] ,Interrupt SPI[202] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICLR[201] ,Interrupt SPI[201] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICLR[200] ,Interrupt SPI[200] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICLR[199] ,Interrupt SPI[199] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICLR[198] ,Interrupt SPI[198] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICLR[197] ,Interrupt SPI[197] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 4. " ICLR[196] ,Interrupt SPI[196] Clear" "No effect,Cleared"
        bitfld.long 0x00 3. "  ICLR[195] ,Interrupt SPI[195] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICLR[194] ,Interrupt SPI[194] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 1. " ICLR[193] ,Interrupt SPI[193] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICLR[192] ,Interrupt SPI[192] Clear" "No effect,Cleared"
tree.end
width 9.
tree "Interrupt Set-Pending Registers"    
group.long 0x200++0x03
    line.long 0x00 "IDISPR0,Interrupt Set-Pending Register 0"
        bitfld.long 0x00 31. " ISPP[3]  ,Interrupt PPI[3] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISPP[2]  ,Interrupt PPI[2] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISPP[1]  ,Interrupt PPI[1] Set" "No effect,Set"
        bitfld.long 0x00 28. "  ISPP[0]  ,Interrupt PPI[0] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 15. " ISPS[15] ,Interrupt STI[15] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISPS[14] ,Interrupt STI[14] Set" "No effect,Set"
        bitfld.long 0x00 13. "  ISPS[13] ,Interrupt STI[13] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISPS[12] ,Interrupt STI[12] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 11. " ISPS[11] ,Interrupt STI[11] Set" "No effect,Set"
        bitfld.long 0x00 10. "  ISPS[10] ,Interrupt STI[10] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISPS[9]  ,Interrupt STI[9] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISPS[8]  ,Interrupt STI[8] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 7. " ISPS[7]  ,Interrupt STI[7] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISPS[6]  ,Interrupt STI[6] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISPS[5]  ,Interrupt STI[5] Set" "No effect,Set"
        bitfld.long 0x00 4. "  ISPS[4]  ,Interrupt STI[4] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 3. " ISPS[3]  ,Interrupt STI[3] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISPS[2]  ,Interrupt STI[2] Set" "No effect,Set"
        bitfld.long 0x00 1. "  ISPS[1]  ,Interrupt STI[1] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISPS[0]  ,Interrupt STI[0] Set" "No effect,Set"
group.long 0x204++0x03
    line.long 0x00 "IDISPR1,Interrupt Set-Pending Register 1"        
        bitfld.long 0x00 31. " ISP[31]  ,Interrupt SPI[31] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISP[30]  ,Interrupt SPI[30] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISP[29]  ,Interrupt SPI[29] Set" "No effect,Set"
        bitfld.long 0x00 28. "  ISP[28]  ,Interrupt SPI[28] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 27. " ISP[27]  ,Interrupt SPI[27] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISP[26]  ,Interrupt SPI[26] Set" "No effect,Set"
        bitfld.long 0x00 25. "  ISP[25]  ,Interrupt SPI[25] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISP[24]  ,Interrupt SPI[24] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 23. " ISP[23]  ,Interrupt SPI[23] Set" "No effect,Set"
        bitfld.long 0x00 22. "  ISP[22]  ,Interrupt SPI[22] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISP[21]  ,Interrupt SPI[21] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISP[20]  ,Interrupt SPI[20] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 19. " ISP[19]  ,Interrupt SPI[19] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISP[18]  ,Interrupt SPI[18] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISP[17]  ,Interrupt SPI[17] Set" "No effect,Set"
        bitfld.long 0x00 16. "  ISP[16]  ,Interrupt SPI[16] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 15. " ISP[15]  ,Interrupt SPI[15] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISP[14]  ,Interrupt SPI[14] Set" "No effect,Set"
        bitfld.long 0x00 13. "  ISP[13]  ,Interrupt SPI[13] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISP[12]  ,Interrupt SPI[12] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 11. " ISP[11]  ,Interrupt SPI[11] Set" "No effect,Set"
        bitfld.long 0x00 10. "  ISP[10]  ,Interrupt SPI[10] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISP[9]   ,Interrupt SPI[9] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISP[8]   ,Interrupt SPI[8] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 7. " ISP[7]   ,Interrupt SPI[7] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISP[6]   ,Interrupt SPI[6] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISP[5]   ,Interrupt SPI[5] Set" "No effect,Set"
        bitfld.long 0x00 4. "  ISP[4]   ,Interrupt SPI[4] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 3. " ISP[3]   ,Interrupt SPI[3] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISP[2]   ,Interrupt SPI[2] Set" "No effect,Set"
        bitfld.long 0x00 1. "  ISP[1]   ,Interrupt SPI[1] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISP[0]   ,Interrupt SPI[0] Set" "No effect,Set"                
group.long 0x208++0x03
    line.long 0x00 "IDISPR2,Interrupt Set-Pending Register 2"
        bitfld.long 0x00 31. " ISP[63]  ,Interrupt SPI[63] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISP[62]  ,Interrupt SPI[62] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISP[61]  ,Interrupt SPI[61] Set" "No effect,Set"
        bitfld.long 0x00 28. "  ISP[60]  ,Interrupt SPI[60] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 27. " ISP[59]  ,Interrupt SPI[59] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISP[58]  ,Interrupt SPI[58] Set" "No effect,Set"
        bitfld.long 0x00 25. "  ISP[57]  ,Interrupt SPI[57] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISP[56]  ,Interrupt SPI[56] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 23. " ISP[55]  ,Interrupt SPI[55] Set" "No effect,Set"
        bitfld.long 0x00 22. "  ISP[54]  ,Interrupt SPI[54] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISP[53]  ,Interrupt SPI[53] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISP[52]  ,Interrupt SPI[52] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 19. " ISP[51]  ,Interrupt SPI[51] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISP[50]  ,Interrupt SPI[50] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISP[49]  ,Interrupt SPI[49] Set" "No effect,Set"
        bitfld.long 0x00 16. "  ISP[48]  ,Interrupt SPI[48] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 15. " ISP[47]  ,Interrupt SPI[47] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISP[46]  ,Interrupt SPI[46] Set" "No effect,Set"
        bitfld.long 0x00 13. "  ISP[45]  ,Interrupt SPI[45] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISP[44]  ,Interrupt SPI[44] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 11. " ISP[43]  ,Interrupt SPI[43] Set" "No effect,Set"
        bitfld.long 0x00 10. "  ISP[42]  ,Interrupt SPI[42] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISP[41]  ,Interrupt SPI[41] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISP[40]  ,Interrupt SPI[40] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 7. " ISP[39]  ,Interrupt SPI[39] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISP[38]  ,Interrupt SPI[38] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISP[37]  ,Interrupt SPI[37] Set" "No effect,Set"
        bitfld.long 0x00 4. "  ISP[36]  ,Interrupt SPI[36] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 3. " ISP[35]  ,Interrupt SPI[35] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISP[34]  ,Interrupt SPI[34] Set" "No effect,Set"
        bitfld.long 0x00 1. "  ISP[33]  ,Interrupt SPI[33] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISP[32]  ,Interrupt SPI[32] Set" "No effect,Set"
group.long 0x20c++0x03
    line.long 0x00 "IDISPR3,Interrupt Set-Pending Register 3"    
        bitfld.long 0x00 31. " ISP[95]  ,Interrupt SPI[95] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISP[94]  ,Interrupt SPI[94] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISP[93]  ,Interrupt SPI[93] Set" "No effect,Set"
        bitfld.long 0x00 28. "  ISP[92]  ,Interrupt SPI[92] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 27. " ISP[91]  ,Interrupt SPI[91] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISP[90]  ,Interrupt SPI[90] Set" "No effect,Set"
        bitfld.long 0x00 25. "  ISP[89]  ,Interrupt SPI[89] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISP[88]  ,Interrupt SPI[88] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 23. " ISP[87]  ,Interrupt SPI[87] Set" "No effect,Set"
        bitfld.long 0x00 22. "  ISP[86]  ,Interrupt SPI[86] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISP[85]  ,Interrupt SPI[85] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISP[84]  ,Interrupt SPI[84] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 19. " ISP[83]  ,Interrupt SPI[83] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISP[82]  ,Interrupt SPI[82] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISP[81]  ,Interrupt SPI[81] Set" "No effect,Set"
        bitfld.long 0x00 16. "  ISP[80]  ,Interrupt SPI[80] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 15. " ISP[79]  ,Interrupt SPI[79] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISP[78]  ,Interrupt SPI[78] Set" "No effect,Set"
        bitfld.long 0x00 13. "  ISP[77]  ,Interrupt SPI[77] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISP[76]  ,Interrupt SPI[76] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 11. " ISP[75]  ,Interrupt SPI[75] Set" "No effect,Set"
        bitfld.long 0x00 10. "  ISP[74]  ,Interrupt SPI[74] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISP[73]  ,Interrupt SPI[73] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISP[72]  ,Interrupt SPI[72] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 7. " ISP[71]  ,Interrupt SPI[71] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISP[70]  ,Interrupt SPI[70] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISP[69]  ,Interrupt SPI[69] Set" "No effect,Set"
        bitfld.long 0x00 4. "  ISP[68]  ,Interrupt SPI[68] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 3. " ISP[67]  ,Interrupt SPI[67] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISP[66]  ,Interrupt SPI[66] Set" "No effect,Set"
        bitfld.long 0x00 1. "  ISP[65]  ,Interrupt SPI[65] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISP[64]  ,Interrupt SPI[64] Set" "No effect,Set"
group.long 0x210++0x03
    line.long 0x00 "IDISPR4,Interrupt Set-Pending Register 4"
        bitfld.long 0x00 31. " ISP[127] ,Interrupt SPI[127] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISP[126] ,Interrupt SPI[126] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISP[125] ,Interrupt SPI[125] Set" "No effect,Set"
        bitfld.long 0x00 28. "  ISP[124] ,Interrupt SPI[124] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 27. " ISP[123] ,Interrupt SPI[123] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISP[122] ,Interrupt SPI[122] Set" "No effect,Set"
        bitfld.long 0x00 25. "  ISP[121] ,Interrupt SPI[121] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISP[120] ,Interrupt SPI[120] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 23. " ISP[119] ,Interrupt SPI[119] Set" "No effect,Set"
        bitfld.long 0x00 22. "  ISP[118] ,Interrupt SPI[118] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISP[117] ,Interrupt SPI[117] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISP[116] ,Interrupt SPI[116] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 19. " ISP[115] ,Interrupt SPI[115] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISP[114] ,Interrupt SPI[114] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISP[113] ,Interrupt SPI[113] Set" "No effect,Set"
        bitfld.long 0x00 16. "  ISP[112] ,Interrupt SPI[112] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 15. " ISP[111] ,Interrupt SPI[111] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISP[110] ,Interrupt SPI[110] Set" "No effect,Set"
        bitfld.long 0x00 13. "  ISP[109] ,Interrupt SPI[109] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISP[108] ,Interrupt SPI[108] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 11. " ISP[107] ,Interrupt SPI[107] Set" "No effect,Set"
        bitfld.long 0x00 10. "  ISP[106] ,Interrupt SPI[106] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISP[105] ,Interrupt SPI[105] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISP[104] ,Interrupt SPI[104] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 7. " ISP[103] ,Interrupt SPI[103] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISP[102] ,Interrupt SPI[102] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISP[101] ,Interrupt SPI[101] Set" "No effect,Set"
        bitfld.long 0x00 4. "  ISP[100] ,Interrupt SPI[100] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 3. " ISP[99]  ,Interrupt SPI[99] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISP[98]  ,Interrupt SPI[98] Set" "No effect,Set"
        bitfld.long 0x00 1. "  ISP[97]  ,Interrupt SPI[97] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISP[96]  ,Interrupt SPI[96] Set" "No effect,Set"
group.long 0x214++0x03
    line.long 0x00 "IDISPR5,Interrupt Set-Pending Register 5"    
        bitfld.long 0x00 31. " ISP[159] ,Interrupt SPI[159] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISP[158] ,Interrupt SPI[158] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISP[157] ,Interrupt SPI[157] Set" "No effect,Set"
        bitfld.long 0x00 28. "  ISP[156] ,Interrupt SPI[156] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 27. " ISP[155] ,Interrupt SPI[155] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISP[154] ,Interrupt SPI[154] Set" "No effect,Set"
        bitfld.long 0x00 25. "  ISP[153] ,Interrupt SPI[153] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISP[152] ,Interrupt SPI[152] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 23. " ISP[151] ,Interrupt SPI[151] Set" "No effect,Set"
        bitfld.long 0x00 22. "  ISP[150] ,Interrupt SPI[150] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISP[149] ,Interrupt SPI[149] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISP[148] ,Interrupt SPI[148] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 19. " ISP[147] ,Interrupt SPI[147] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISP[146] ,Interrupt SPI[146] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISP[145] ,Interrupt SPI[145] Set" "No effect,Set"
        bitfld.long 0x00 16. "  ISP[144] ,Interrupt SPI[144] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 15. " ISP[143] ,Interrupt SPI[143] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISP[142] ,Interrupt SPI[142] Set" "No effect,Set"
        bitfld.long 0x00 13. "  ISP[141] ,Interrupt SPI[141] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISP[140] ,Interrupt SPI[140] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 11. " ISP[139] ,Interrupt SPI[139] Set" "No effect,Set"
        bitfld.long 0x00 10. "  ISP[138] ,Interrupt SPI[138] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISP[137] ,Interrupt SPI[137] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISP[136] ,Interrupt SPI[136] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 7. " ISP[135] ,Interrupt SPI[135] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISP[134] ,Interrupt SPI[134] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISP[133] ,Interrupt SPI[133] Set" "No effect,Set"
        bitfld.long 0x00 4. "  ISP[132] ,Interrupt SPI[132] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 3. " ISP[131] ,Interrupt SPI[131] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISP[130] ,Interrupt SPI[130] Set" "No effect,Set"
        bitfld.long 0x00 1. "  ISP[129] ,Interrupt SPI[129] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISP[128] ,Interrupt SPI[128] Set" "No effect,Set"
group.long 0x218++0x03
    line.long 0x00 "IDISPR6,Interrupt Set-Pending Register 6"        
        bitfld.long 0x00 31. " ISP[191] ,Interrupt SPI[191] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISP[190] ,Interrupt SPI[190] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISP[189] ,Interrupt SPI[189] Set" "No effect,Set"
        bitfld.long 0x00 28. "  ISP[188] ,Interrupt SPI[188] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 27. " ISP[187] ,Interrupt SPI[187] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISP[186] ,Interrupt SPI[186] Set" "No effect,Set"
        bitfld.long 0x00 25. "  ISP[185] ,Interrupt SPI[185] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISP[184] ,Interrupt SPI[184] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 23. " ISP[183] ,Interrupt SPI[183] Set" "No effect,Set"
        bitfld.long 0x00 22. "  ISP[182] ,Interrupt SPI[182] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISP[181] ,Interrupt SPI[181] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISP[180] ,Interrupt SPI[180] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 19. " ISP[179] ,Interrupt SPI[179] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISP[178] ,Interrupt SPI[178] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISP[177] ,Interrupt SPI[177] Set" "No effect,Set"
        bitfld.long 0x00 16. "  ISP[176] ,Interrupt SPI[176] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 15. " ISP[175] ,Interrupt SPI[175] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISP[174] ,Interrupt SPI[174] Set" "No effect,Set"
        bitfld.long 0x00 13. "  ISP[173] ,Interrupt SPI[173] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISP[172] ,Interrupt SPI[172] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 11. " ISP[171] ,Interrupt SPI[171] Set" "No effect,Set"
        bitfld.long 0x00 10. "  ISP[170] ,Interrupt SPI[170] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISP[169] ,Interrupt SPI[169] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISP[168] ,Interrupt SPI[168] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 7. " ISP[167] ,Interrupt SPI[167] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISP[166] ,Interrupt SPI[166] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISP[165] ,Interrupt SPI[165] Set" "No effect,Set"
        bitfld.long 0x00 4. "  ISP[164] ,Interrupt SPI[164] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 3. " ISP[163] ,Interrupt SPI[163] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISP[162] ,Interrupt SPI[162] Set" "No effect,Set"
        bitfld.long 0x00 1. "  ISP[161] ,Interrupt SPI[161] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISP[160] ,Interrupt SPI[160] Set" "No effect,Set"
group.long 0x21c++0x03
    line.long 0x00 "IDISPR7,Interrupt Set-Pending Register 7"        
        bitfld.long 0x00 31. " ISP[223] ,Interrupt SPI[223] Set" "No effect,Set"
        bitfld.long 0x00 30. "  ISP[222] ,Interrupt SPI[222] Set" "No effect,Set"
        bitfld.long 0x00 29. "  ISP[221] ,Interrupt SPI[221] Set" "No effect,Set"
        bitfld.long 0x00 28. "  ISP[220] ,Interrupt SPI[220] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 27. " ISP[219] ,Interrupt SPI[219] Set" "No effect,Set"
        bitfld.long 0x00 26. "  ISP[218] ,Interrupt SPI[218] Set" "No effect,Set"
        bitfld.long 0x00 25. "  ISP[217] ,Interrupt SPI[217] Set" "No effect,Set"
        bitfld.long 0x00 24. "  ISP[216] ,Interrupt SPI[216] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 23. " ISP[215] ,Interrupt SPI[215] Set" "No effect,Set"
        bitfld.long 0x00 22. "  ISP[214] ,Interrupt SPI[214] Set" "No effect,Set"
        bitfld.long 0x00 21. "  ISP[213] ,Interrupt SPI[213] Set" "No effect,Set"
        bitfld.long 0x00 20. "  ISP[212] ,Interrupt SPI[212] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 19. " ISP[211] ,Interrupt SPI[211] Set" "No effect,Set"
        bitfld.long 0x00 18. "  ISP[210] ,Interrupt SPI[210] Set" "No effect,Set"
        bitfld.long 0x00 17. "  ISP[209] ,Interrupt SPI[209] Set" "No effect,Set"
        bitfld.long 0x00 16. "  ISP[208] ,Interrupt SPI[208] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 15. " ISP[207] ,Interrupt SPI[207] Set" "No effect,Set"
        bitfld.long 0x00 14. "  ISP[206] ,Interrupt SPI[206] Set" "No effect,Set"
        bitfld.long 0x00 13. "  ISP[205] ,Interrupt SPI[205] Set" "No effect,Set"
        bitfld.long 0x00 12. "  ISP[204] ,Interrupt SPI[204] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 11. " ISP[203] ,Interrupt SPI[203] Set" "No effect,Set"
        bitfld.long 0x00 10. "  ISP[202] ,Interrupt SPI[202] Set" "No effect,Set"
        bitfld.long 0x00 9. "  ISP[201] ,Interrupt SPI[201] Set" "No effect,Set"
        bitfld.long 0x00 8. "  ISP[200] ,Interrupt SPI[200] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 7. " ISP[199] ,Interrupt SPI[199] Set" "No effect,Set"
        bitfld.long 0x00 6. "  ISP[198] ,Interrupt SPI[198] Set" "No effect,Set"
        bitfld.long 0x00 5. "  ISP[197] ,Interrupt SPI[197] Set" "No effect,Set"
        bitfld.long 0x00 4. "  ISP[196] ,Interrupt SPI[196] Set" "No effect,Set"
        textline "                  "
        bitfld.long 0x00 3. " ISP[195] ,Interrupt SPI[195] Set" "No effect,Set"
        bitfld.long 0x00 2. "  ISP[194] ,Interrupt SPI[194] Set" "No effect,Set"
        bitfld.long 0x00 1. "  ISP[193] ,Interrupt SPI[193] Set" "No effect,Set"
        bitfld.long 0x00 0. "  ISP[192] ,Interrupt SPI[192] Set" "No effect,Set"
tree.end
width 10.
tree "Interrupt Clear-Pending Registers"    
group.long 0x280++0x03
    line.long 0x00 "ICDICPR0,Interrupt Clear-Pending Register 0"
        bitfld.long 0x00 31. " ICPP[3]  ,Interrupt PPI[3] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICPP[2]  ,Interrupt PPI[2] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICPP[1]  ,Interrupt PPI[1] Clear" "No effect,Cleared"
        bitfld.long 0x00 28. "  ICPP[0]  ,Interrupt PPI[0] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 15. " ICPS[15] ,Interrupt STI[15] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICPS[14] ,Interrupt STI[14] Clear" "No effect,Cleared"
        bitfld.long 0x00 13. "  ICPS[13] ,Interrupt STI[13] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICPS[12] ,Interrupt STI[12] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 11. " ICPS[11] ,Interrupt STI[11] Clear" "No effect,Cleared"
        bitfld.long 0x00 10. "  ICPS[10] ,Interrupt STI[10] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICPS[9]  ,Interrupt STI[9] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICPS[8]  ,Interrupt STI[8] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICPS[7]  ,Interrupt STI[7] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICPS[6]  ,Interrupt STI[6] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICPS[5]  ,Interrupt STI[5] Clear" "No effect,Cleared"
        bitfld.long 0x00 4. "  ICPS[4]  ,Interrupt STI[4] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 3. " ICPS[3]  ,Interrupt STI[3] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICPS[2]  ,Interrupt STI[2] Clear" "No effect,Cleared"
        bitfld.long 0x00 1. "  ICPS[1]  ,Interrupt STI[1] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICPS[0]  ,Interrupt STI[0] Clear" "No effect,Cleared"
group.long 0x284++0x03
    line.long 0x00 "ICDICPR1,Interrupt Clear-Pending Register 1"        
        bitfld.long 0x00 31. " ICP[31]  ,Interrupt SPI[31] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICP[30]  ,Interrupt SPI[30] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICP[29]  ,Interrupt SPI[29] Clear" "No effect,Cleared"
        bitfld.long 0x00 28. "  ICP[28]  ,Interrupt SPI[28] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 27. " ICP[27]  ,Interrupt SPI[27] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICP[26]  ,Interrupt SPI[26] Clear" "No effect,Cleared"
        bitfld.long 0x00 25. "  ICP[25]  ,Interrupt SPI[25] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICP[24]  ,Interrupt SPI[24] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 23. " ICP[23]  ,Interrupt SPI[23] Clear" "No effect,Cleared"
        bitfld.long 0x00 22. "  ICP[22]  ,Interrupt SPI[22] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICP[21]  ,Interrupt SPI[21] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICP[20]  ,Interrupt SPI[20] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICP[19]  ,Interrupt SPI[19] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICP[18]  ,Interrupt SPI[18] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICP[17]  ,Interrupt SPI[17] Clear" "No effect,Cleared"
        bitfld.long 0x00 16. "  ICP[16]  ,Interrupt SPI[16] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 15. " ICP[15]  ,Interrupt SPI[15] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICP[14]  ,Interrupt SPI[14] Clear" "No effect,Cleared"
        bitfld.long 0x00 13. "  ICP[13]  ,Interrupt SPI[13] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICP[12]  ,Interrupt SPI[12] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 11. " ICP[11]  ,Interrupt SPI[11] Clear" "No effect,Cleared"
        bitfld.long 0x00 10. "  ICP[10]  ,Interrupt SPI[10] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICP[9]   ,Interrupt SPI[9] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICP[8]   ,Interrupt SPI[8] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICP[7]   ,Interrupt SPI[7] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICP[6]   ,Interrupt SPI[6] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICP[5]   ,Interrupt SPI[5] Clear" "No effect,Cleared"
        bitfld.long 0x00 4. "  ICP[4]   ,Interrupt SPI[4] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 3. " ICP[3]   ,Interrupt SPI[3] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICP[2]   ,Interrupt SPI[2] Clear" "No effect,Cleared"
        bitfld.long 0x00 1. "  ICP[1]   ,Interrupt SPI[1] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICP[0]   ,Interrupt SPI[0] Clear" "No effect,Cleared"                
group.long 0x288++0x03
    line.long 0x00 "ICDICPR2,Interrupt Clear-Pending Register 2"
        bitfld.long 0x00 31. " ICP[63]  ,Interrupt SPI[63] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICP[62]  ,Interrupt SPI[62] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICP[61]  ,Interrupt SPI[61] Clear" "No effect,Cleared"
        bitfld.long 0x00 28. "  ICP[60]  ,Interrupt SPI[60] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 27. " ICP[59]  ,Interrupt SPI[59] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICP[58]  ,Interrupt SPI[58] Clear" "No effect,Cleared"
        bitfld.long 0x00 25. "  ICP[57]  ,Interrupt SPI[57] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICP[56]  ,Interrupt SPI[56] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 23. " ICP[55]  ,Interrupt SPI[55] Clear" "No effect,Cleared"
        bitfld.long 0x00 22. "  ICP[54]  ,Interrupt SPI[54] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICP[53]  ,Interrupt SPI[53] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICP[52]  ,Interrupt SPI[52] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICP[51]  ,Interrupt SPI[51] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICP[50]  ,Interrupt SPI[50] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICP[49]  ,Interrupt SPI[49] Clear" "No effect,Cleared"
        bitfld.long 0x00 16. "  ICP[48]  ,Interrupt SPI[48] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 15. " ICP[47]  ,Interrupt SPI[47] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICP[46]  ,Interrupt SPI[46] Clear" "No effect,Cleared"
        bitfld.long 0x00 13. "  ICP[45]  ,Interrupt SPI[45] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICP[44]  ,Interrupt SPI[44] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 11. " ICP[43]  ,Interrupt SPI[43] Clear" "No effect,Cleared"
        bitfld.long 0x00 10. "  ICP[42]  ,Interrupt SPI[42] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICP[41]  ,Interrupt SPI[41] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICP[40]  ,Interrupt SPI[40] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICP[39]  ,Interrupt SPI[39] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICP[38]  ,Interrupt SPI[38] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICP[37]  ,Interrupt SPI[37] Clear" "No effect,Cleared"
        bitfld.long 0x00 4. "  ICP[36]  ,Interrupt SPI[36] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 3. " ICP[35]  ,Interrupt SPI[35] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICP[34]  ,Interrupt SPI[34] Clear" "No effect,Cleared"
        bitfld.long 0x00 1. "  ICP[33]  ,Interrupt SPI[33] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICP[32]  ,Interrupt SPI[32] Clear" "No effect,Cleared"
group.long 0x28c++0x03
    line.long 0x00 "ICDICPR3,Interrupt Clear-Pending Register 3"    
        bitfld.long 0x00 31. " ICP[95]  ,Interrupt SPI[95] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICP[94]  ,Interrupt SPI[94] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICP[93]  ,Interrupt SPI[93] Clear" "No effect,Cleared"
        bitfld.long 0x00 28. "  ICP[92]  ,Interrupt SPI[92] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 27. " ICP[91]  ,Interrupt SPI[91] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICP[90]  ,Interrupt SPI[90] Clear" "No effect,Cleared"
        bitfld.long 0x00 25. "  ICP[89]  ,Interrupt SPI[89] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICP[88]  ,Interrupt SPI[88] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 23. " ICP[87]  ,Interrupt SPI[87] Clear" "No effect,Cleared"
        bitfld.long 0x00 22. "  ICP[86]  ,Interrupt SPI[86] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICP[85]  ,Interrupt SPI[85] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICP[84]  ,Interrupt SPI[84] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICP[83]  ,Interrupt SPI[83] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICP[82]  ,Interrupt SPI[82] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICP[81]  ,Interrupt SPI[81] Clear" "No effect,Cleared"
        bitfld.long 0x00 16. "  ICP[80]  ,Interrupt SPI[80] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 15. " ICP[79]  ,Interrupt SPI[79] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICP[78]  ,Interrupt SPI[78] Clear" "No effect,Cleared"
        bitfld.long 0x00 13. "  ICP[77]  ,Interrupt SPI[77] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICP[76]  ,Interrupt SPI[76] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 11. " ICP[75]  ,Interrupt SPI[75] Clear" "No effect,Cleared"
        bitfld.long 0x00 10. "  ICP[74]  ,Interrupt SPI[74] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICP[73]  ,Interrupt SPI[73] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICP[72]  ,Interrupt SPI[72] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICP[71]  ,Interrupt SPI[71] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICP[70]  ,Interrupt SPI[70] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICP[69]  ,Interrupt SPI[69] Clear" "No effect,Cleared"
        bitfld.long 0x00 4. "  ICP[68]  ,Interrupt SPI[68] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 3. " ICP[67]  ,Interrupt SPI[67] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICP[66]  ,Interrupt SPI[66] Clear" "No effect,Cleared"
        bitfld.long 0x00 1. "  ICP[65]  ,Interrupt SPI[65] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICP[64]  ,Interrupt SPI[64] Clear" "No effect,Cleared"
group.long 0x290++0x03
    line.long 0x00 "ICDICPR4,Interrupt Clear-Pending Register 4"
        bitfld.long 0x00 31. " ICP[127] ,Interrupt SPI[127] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICP[126] ,Interrupt SPI[126] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICP[125] ,Interrupt SPI[125] Clear" "No effect,Cleared"
        bitfld.long 0x00 28. "  ICP[124] ,Interrupt SPI[124] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 27. " ICP[123] ,Interrupt SPI[123] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICP[122] ,Interrupt SPI[122] Clear" "No effect,Cleared"
        bitfld.long 0x00 25. "  ICP[121] ,Interrupt SPI[121] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICP[120] ,Interrupt SPI[120] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 23. " ICP[119] ,Interrupt SPI[119] Clear" "No effect,Cleared"
        bitfld.long 0x00 22. "  ICP[118] ,Interrupt SPI[118] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICP[117] ,Interrupt SPI[117] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICP[116] ,Interrupt SPI[116] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICP[115] ,Interrupt SPI[115] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICP[114] ,Interrupt SPI[114] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICP[113] ,Interrupt SPI[113] Clear" "No effect,Cleared"
        bitfld.long 0x00 16. "  ICP[112] ,Interrupt SPI[112] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 15. " ICP[111] ,Interrupt SPI[111] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICP[110] ,Interrupt SPI[110] Clear" "No effect,Cleared"
        bitfld.long 0x00 13. "  ICP[109] ,Interrupt SPI[109] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICP[108] ,Interrupt SPI[108] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 11. " ICP[107] ,Interrupt SPI[107] Clear" "No effect,Cleared"
        bitfld.long 0x00 10. "  ICP[106] ,Interrupt SPI[106] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICP[105] ,Interrupt SPI[105] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICP[104] ,Interrupt SPI[104] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICP[103] ,Interrupt SPI[103] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICP[102] ,Interrupt SPI[102] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICP[101] ,Interrupt SPI[101] Clear" "No effect,Cleared"
        bitfld.long 0x00 4. "  ICP[100] ,Interrupt SPI[100] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 3. " ICP[99]  ,Interrupt SPI[99] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICP[98]  ,Interrupt SPI[98] Clear" "No effect,Cleared"
        bitfld.long 0x00 1. "  ICP[97]  ,Interrupt SPI[97] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICP[96]  ,Interrupt SPI[96] Clear" "No effect,Cleared"
group.long 0x294++0x03
    line.long 0x00 "ICDICPR5,Interrupt Clear-Pending Register 5"    
        bitfld.long 0x00 31. " ICP[159] ,Interrupt SPI[159] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICP[158] ,Interrupt SPI[158] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICP[157] ,Interrupt SPI[157] Clear" "No effect,Cleared"
        bitfld.long 0x00 28. "  ICP[156] ,Interrupt SPI[156] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 27. " ICP[155] ,Interrupt SPI[155] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICP[154] ,Interrupt SPI[154] Clear" "No effect,Cleared"
        bitfld.long 0x00 25. "  ICP[153] ,Interrupt SPI[153] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICP[152] ,Interrupt SPI[152] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 23. " ICP[151] ,Interrupt SPI[151] Clear" "No effect,Cleared"
        bitfld.long 0x00 22. "  ICP[150] ,Interrupt SPI[150] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICP[149] ,Interrupt SPI[149] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICP[148] ,Interrupt SPI[148] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICP[147] ,Interrupt SPI[147] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICP[146] ,Interrupt SPI[146] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICP[145] ,Interrupt SPI[145] Clear" "No effect,Cleared"
        bitfld.long 0x00 16. "  ICP[144] ,Interrupt SPI[144] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 15. " ICP[143] ,Interrupt SPI[143] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICP[142] ,Interrupt SPI[142] Clear" "No effect,Cleared"
        bitfld.long 0x00 13. "  ICP[141] ,Interrupt SPI[141] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICP[140] ,Interrupt SPI[140] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 11. " ICP[139] ,Interrupt SPI[139] Clear" "No effect,Cleared"
        bitfld.long 0x00 10. "  ICP[138] ,Interrupt SPI[138] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICP[137] ,Interrupt SPI[137] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICP[136] ,Interrupt SPI[136] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICP[135] ,Interrupt SPI[135] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICP[134] ,Interrupt SPI[134] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICP[133] ,Interrupt SPI[133] Clear" "No effect,Cleared"
        bitfld.long 0x00 4. "  ICP[132] ,Interrupt SPI[132] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 3. " ICP[131] ,Interrupt SPI[131] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICP[130] ,Interrupt SPI[130] Clear" "No effect,Cleared"
        bitfld.long 0x00 1. "  ICP[129] ,Interrupt SPI[129] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICP[128] ,Interrupt SPI[128] Clear" "No effect,Cleared"
group.long 0x298++0x03
    line.long 0x00 "ICDICPR6,Interrupt Clear-Pending Register 6"        
        bitfld.long 0x00 31. " ICP[191] ,Interrupt SPI[191] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICP[190] ,Interrupt SPI[190] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICP[189] ,Interrupt SPI[189] Clear" "No effect,Cleared"
        bitfld.long 0x00 28. "  ICP[188] ,Interrupt SPI[188] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 27. " ICP[187] ,Interrupt SPI[187] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICP[186] ,Interrupt SPI[186] Clear" "No effect,Cleared"
        bitfld.long 0x00 25. "  ICP[185] ,Interrupt SPI[185] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICP[184] ,Interrupt SPI[184] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 23. " ICP[183] ,Interrupt SPI[183] Clear" "No effect,Cleared"
        bitfld.long 0x00 22. "  ICP[182] ,Interrupt SPI[182] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICP[181] ,Interrupt SPI[181] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICP[180] ,Interrupt SPI[180] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICP[179] ,Interrupt SPI[179] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICP[178] ,Interrupt SPI[178] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICP[177] ,Interrupt SPI[177] Clear" "No effect,Cleared"
        bitfld.long 0x00 16. "  ICP[176] ,Interrupt SPI[176] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 15. " ICP[175] ,Interrupt SPI[175] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICP[174] ,Interrupt SPI[174] Clear" "No effect,Cleared"
        bitfld.long 0x00 13. "  ICP[173] ,Interrupt SPI[173] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICP[172] ,Interrupt SPI[172] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 11. " ICP[171] ,Interrupt SPI[171] Clear" "No effect,Cleared"
        bitfld.long 0x00 10. "  ICP[170] ,Interrupt SPI[170] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICP[169] ,Interrupt SPI[169] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICP[168] ,Interrupt SPI[168] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICP[167] ,Interrupt SPI[167] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICP[166] ,Interrupt SPI[166] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICP[165] ,Interrupt SPI[165] Clear" "No effect,Cleared"
        bitfld.long 0x00 4. "  ICP[164] ,Interrupt SPI[164] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 3. " ICP[163] ,Interrupt SPI[163] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICP[162] ,Interrupt SPI[162] Clear" "No effect,Cleared"
        bitfld.long 0x00 1. "  ICP[161] ,Interrupt SPI[161] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICP[160] ,Interrupt SPI[160] Clear" "No effect,Cleared"
group.long 0x29c++0x03
    line.long 0x00 "ICDICPR7,Interrupt Clear-Pending Register 7"        
        bitfld.long 0x00 31. " ICP[223] ,Interrupt SPI[223] Clear" "No effect,Cleared"
        bitfld.long 0x00 30. "  ICP[222] ,Interrupt SPI[222] Clear" "No effect,Cleared"
        bitfld.long 0x00 29. "  ICP[221] ,Interrupt SPI[221] Clear" "No effect,Cleared"
        bitfld.long 0x00 28. "  ICP[220] ,Interrupt SPI[220] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 27. " ICP[219] ,Interrupt SPI[219] Clear" "No effect,Cleared"
        bitfld.long 0x00 26. "  ICP[218] ,Interrupt SPI[218] Clear" "No effect,Cleared"
        bitfld.long 0x00 25. "  ICP[217] ,Interrupt SPI[217] Clear" "No effect,Cleared"
        bitfld.long 0x00 24. "  ICP[216] ,Interrupt SPI[216] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 23. " ICP[215] ,Interrupt SPI[215] Clear" "No effect,Cleared"
        bitfld.long 0x00 22. "  ICP[214] ,Interrupt SPI[214] Clear" "No effect,Cleared"
        bitfld.long 0x00 21. "  ICP[213] ,Interrupt SPI[213] Clear" "No effect,Cleared"
        bitfld.long 0x00 20. "  ICP[212] ,Interrupt SPI[212] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 19. " ICP[211] ,Interrupt SPI[211] Clear" "No effect,Cleared"
        bitfld.long 0x00 18. "  ICP[210] ,Interrupt SPI[210] Clear" "No effect,Cleared"
        bitfld.long 0x00 17. "  ICP[209] ,Interrupt SPI[209] Clear" "No effect,Cleared"
        bitfld.long 0x00 16. "  ICP[208] ,Interrupt SPI[208] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 15. " ICP[207] ,Interrupt SPI[207] Clear" "No effect,Cleared"
        bitfld.long 0x00 14. "  ICP[206] ,Interrupt SPI[206] Clear" "No effect,Cleared"
        bitfld.long 0x00 13. "  ICP[205] ,Interrupt SPI[205] Clear" "No effect,Cleared"
        bitfld.long 0x00 12. "  ICP[204] ,Interrupt SPI[204] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 11. " ICP[203] ,Interrupt SPI[203] Clear" "No effect,Cleared"
        bitfld.long 0x00 10. "  ICP[202] ,Interrupt SPI[202] Clear" "No effect,Cleared"
        bitfld.long 0x00 9. "  ICP[201] ,Interrupt SPI[201] Clear" "No effect,Cleared"
        bitfld.long 0x00 8. "  ICP[200] ,Interrupt SPI[200] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 7. " ICP[199] ,Interrupt SPI[199] Clear" "No effect,Cleared"
        bitfld.long 0x00 6. "  ICP[198] ,Interrupt SPI[198] Clear" "No effect,Cleared"
        bitfld.long 0x00 5. "  ICP[197] ,Interrupt SPI[197] Clear" "No effect,Cleared"
        bitfld.long 0x00 4. "  ICP[196] ,Interrupt SPI[196] Clear" "No effect,Cleared"
        textline "                   "
        bitfld.long 0x00 3. " ICP[195] ,Interrupt SPI[195] Clear" "No effect,Cleared"
        bitfld.long 0x00 2. "  ICP[194] ,Interrupt SPI[194] Clear" "No effect,Cleared"
        bitfld.long 0x00 1. "  ICP[193] ,Interrupt SPI[193] Clear" "No effect,Cleared"
        bitfld.long 0x00 0. "  ICP[192] ,Interrupt SPI[192] Clear" "No effect,Cleared"
tree.end
width 9.
tree "Active Bit registers"        
rgroup.long 0x300++0x03
    line.long 0x00 "ICDABR0,Active Bit Register 0"
        bitfld.long 0x00 31. " ABP[3]  ,Active Bit PPI[3]" "Inactive,Active"
        bitfld.long 0x00 30. "  ABP[2]  ,Active Bit PPI[2]" "Inactive,Active"
        bitfld.long 0x00 29. "  ABP[1]  ,Active Bit PPI[1]" "Inactive,Active"
        bitfld.long 0x00 28. "  ABP[0]  ,Active Bit PPI[0]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 15. " ABS[15] ,Active Bit STI[15]" "Inactive,Active"
        bitfld.long 0x00 14. "  ABS[14] ,Active Bit STI[14]" "Inactive,Active"
        bitfld.long 0x00 13. "  ABS[13] ,Active Bit STI[13]" "Inactive,Active"
        bitfld.long 0x00 12. "  ABS[12] ,Active Bit STI[12]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 11. " ABS[11] ,Active Bit STI[11]" "Inactive,Active"
        bitfld.long 0x00 10. "  ABS[10] ,Active Bit STI[10]" "Inactive,Active"
        bitfld.long 0x00 9. "  ABS[9]  ,Active Bit STI[9]" "Inactive,Active"
        bitfld.long 0x00 8. "  ABS[8]  ,Active Bit STI[8]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 7. " ABS[7]  ,Active Bit STI[7]" "Inactive,Active"
        bitfld.long 0x00 6. "  ABS[6]  ,Active Bit STI[6]" "Inactive,Active"
        bitfld.long 0x00 5. "  ABS[5]  ,Active Bit STI[5]" "Inactive,Active"
        bitfld.long 0x00 4. "  ABS[4]  ,Active Bit STI[4]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 3. " ABS[3]  ,Active Bit STI[3]" "Inactive,Active"
        bitfld.long 0x00 2. "  ABS[2]  ,Active Bit STI[2]" "Inactive,Active"
        bitfld.long 0x00 1. "  ABS[1]  ,Active Bit STI[1]" "Inactive,Active"
        bitfld.long 0x00 0. "  ABS[0]  ,Active Bit STI[0]" "Inactive,Active"
rgroup.long 0x304++0x03
    line.long 0x00 "ICDABR1,Active Bit Register 1"        
        bitfld.long 0x00 31. " AB[31]  ,Active Bit SPI[31]" "Inactive,Active"
        bitfld.long 0x00 30. "  AB[30]  ,Active Bit SPI[30]" "Inactive,Active"
        bitfld.long 0x00 29. "  AB[29]  ,Active Bit SPI[29]" "Inactive,Active"
        bitfld.long 0x00 28. "  AB[28]  ,Active Bit SPI[28]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 27. " AB[27]  ,Active Bit SPI[27]" "Inactive,Active"
        bitfld.long 0x00 26. "  AB[26]  ,Active Bit SPI[26]" "Inactive,Active"
        bitfld.long 0x00 25. "  AB[25]  ,Active Bit SPI[25]" "Inactive,Active"
        bitfld.long 0x00 24. "  AB[24]  ,Active Bit SPI[24]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 23. " AB[23]  ,Active Bit SPI[23]" "Inactive,Active"
        bitfld.long 0x00 22. "  AB[22]  ,Active Bit SPI[22]" "Inactive,Active"
        bitfld.long 0x00 21. "  AB[21]  ,Active Bit SPI[21]" "Inactive,Active"
        bitfld.long 0x00 20. "  AB[20]  ,Active Bit SPI[20]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 19. " AB[19]  ,Active Bit SPI[19]" "Inactive,Active"
        bitfld.long 0x00 18. "  AB[18]  ,Active Bit SPI[18]" "Inactive,Active"
        bitfld.long 0x00 17. "  AB[17]  ,Active Bit SPI[17]" "Inactive,Active"
        bitfld.long 0x00 16. "  AB[16]  ,Active Bit SPI[16]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 15. " AB[15]  ,Active Bit SPI[15]" "Inactive,Active"
        bitfld.long 0x00 14. "  AB[14]  ,Active Bit SPI[14]" "Inactive,Active"
        bitfld.long 0x00 13. "  AB[13]  ,Active Bit SPI[13]" "Inactive,Active"
        bitfld.long 0x00 12. "  AB[12]  ,Active Bit SPI[12]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 11. " AB[11]  ,Active Bit SPI[11]" "Inactive,Active"
        bitfld.long 0x00 10. "  AB[10]  ,Active Bit SPI[10]" "Inactive,Active"
        bitfld.long 0x00 9. "  AB[9]   ,Active Bit SPI[9]" "Inactive,Active"
        bitfld.long 0x00 8. "  AB[8]   ,Active Bit SPI[8]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 7. " AB[7]   ,Active Bit SPI[7]" "Inactive,Active"
        bitfld.long 0x00 6. "  AB[6]   ,Active Bit SPI[6]" "Inactive,Active"
        bitfld.long 0x00 5. "  AB[5]   ,Active Bit SPI[5]" "Inactive,Active"
        bitfld.long 0x00 4. "  AB[4]   ,Active Bit SPI[4]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 3. " AB[3]   ,Active Bit SPI[3]" "Inactive,Active"
        bitfld.long 0x00 2. "  AB[2]   ,Active Bit SPI[2]" "Inactive,Active"
        bitfld.long 0x00 1. "  AB[1]   ,Active Bit SPI[1]" "Inactive,Active"
        bitfld.long 0x00 0. "  AB[0]   ,Active Bit SPI[0]" "Inactive,Active"            
rgroup.long 0x308++0x03
    line.long 0x00 "ICDABR2,Active Bit Register 2"
        bitfld.long 0x00 31. " AB[63]  ,Active Bit SPI[63]" "Inactive,Active"
        bitfld.long 0x00 30. "  AB[62]  ,Active Bit SPI[62]" "Inactive,Active"
        bitfld.long 0x00 29. "  AB[61]  ,Active Bit SPI[61]" "Inactive,Active"
        bitfld.long 0x00 28. "  AB[60]  ,Active Bit SPI[60]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 27. " AB[59]  ,Active Bit SPI[59]" "Inactive,Active"
        bitfld.long 0x00 26. "  AB[58]  ,Active Bit SPI[58]" "Inactive,Active"
        bitfld.long 0x00 25. "  AB[57]  ,Active Bit SPI[57]" "Inactive,Active"
        bitfld.long 0x00 24. "  AB[56]  ,Active Bit SPI[56]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 23. " AB[55]  ,Active Bit SPI[55]" "Inactive,Active"
        bitfld.long 0x00 22. "  AB[54]  ,Active Bit SPI[54]" "Inactive,Active"
        bitfld.long 0x00 21. "  AB[53]  ,Active Bit SPI[53]" "Inactive,Active"
        bitfld.long 0x00 20. "  AB[52]  ,Active Bit SPI[52]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 19. " AB[51]  ,Active Bit SPI[51]" "Inactive,Active"
        bitfld.long 0x00 18. "  AB[50]  ,Active Bit SPI[50]" "Inactive,Active"
        bitfld.long 0x00 17. "  AB[49]  ,Active Bit SPI[49]" "Inactive,Active"
        bitfld.long 0x00 16. "  AB[48]  ,Active Bit SPI[48]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 15. " AB[47]  ,Active Bit SPI[47]" "Inactive,Active"
        bitfld.long 0x00 14. "  AB[46]  ,Active Bit SPI[46]" "Inactive,Active"
        bitfld.long 0x00 13. "  AB[45]  ,Active Bit SPI[45]" "Inactive,Active"
        bitfld.long 0x00 12. "  AB[44]  ,Active Bit SPI[44]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 11. " AB[43]  ,Active Bit SPI[43]" "Inactive,Active"
        bitfld.long 0x00 10. "  AB[42]  ,Active Bit SPI[42]" "Inactive,Active"
        bitfld.long 0x00 9. "  AB[41]  ,Active Bit SPI[41]" "Inactive,Active"
        bitfld.long 0x00 8. "  AB[40]  ,Active Bit SPI[40]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 7. " AB[39]  ,Active Bit SPI[39]" "Inactive,Active"
        bitfld.long 0x00 6. "  AB[38]  ,Active Bit SPI[38]" "Inactive,Active"
        bitfld.long 0x00 5. "  AB[37]  ,Active Bit SPI[37]" "Inactive,Active"
        bitfld.long 0x00 4. "  AB[36]  ,Active Bit SPI[36]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 3. " AB[35]  ,Active Bit SPI[35]" "Inactive,Active"
        bitfld.long 0x00 2. "  AB[34]  ,Active Bit SPI[34]" "Inactive,Active"
        bitfld.long 0x00 1. "  AB[33]  ,Active Bit SPI[33]" "Inactive,Active"
        bitfld.long 0x00 0. "  AB[32]  ,Active Bit SPI[32]" "Inactive,Active"
rgroup.long 0x30c++0x03
    line.long 0x00 "ICDABR3,Active Bit Register 3"    
        bitfld.long 0x00 31. " AB[95]  ,Active Bit SPI[95]" "Inactive,Active"
        bitfld.long 0x00 30. "  AB[94]  ,Active Bit SPI[94]" "Inactive,Active"
        bitfld.long 0x00 29. "  AB[93]  ,Active Bit SPI[93]" "Inactive,Active"
        bitfld.long 0x00 28. "  AB[92]  ,Active Bit SPI[92]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 27. " AB[91]  ,Active Bit SPI[91]" "Inactive,Active"
        bitfld.long 0x00 26. "  AB[90]  ,Active Bit SPI[90]" "Inactive,Active"
        bitfld.long 0x00 25. "  AB[89]  ,Active Bit SPI[89]" "Inactive,Active"
        bitfld.long 0x00 24. "  AB[88]  ,Active Bit SPI[88]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 23. " AB[87]  ,Active Bit SPI[87]" "Inactive,Active"
        bitfld.long 0x00 22. "  AB[86]  ,Active Bit SPI[86]" "Inactive,Active"
        bitfld.long 0x00 21. "  AB[85]  ,Active Bit SPI[85]" "Inactive,Active"
        bitfld.long 0x00 20. "  AB[84]  ,Active Bit SPI[84]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 19. " AB[83]  ,Active Bit SPI[83]" "Inactive,Active"
        bitfld.long 0x00 18. "  AB[82]  ,Active Bit SPI[82]" "Inactive,Active"
        bitfld.long 0x00 17. "  AB[81]  ,Active Bit SPI[81]" "Inactive,Active"
        bitfld.long 0x00 16. "  AB[80]  ,Active Bit SPI[80]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 15. " AB[79]  ,Active Bit SPI[79]" "Inactive,Active"
        bitfld.long 0x00 14. "  AB[78]  ,Active Bit SPI[78]" "Inactive,Active"
        bitfld.long 0x00 13. "  AB[77]  ,Active Bit SPI[77]" "Inactive,Active"
        bitfld.long 0x00 12. "  AB[76]  ,Active Bit SPI[76]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 11. " AB[75]  ,Active Bit SPI[75]" "Inactive,Active"
        bitfld.long 0x00 10. "  AB[74]  ,Active Bit SPI[74]" "Inactive,Active"
        bitfld.long 0x00 9. "  AB[73]  ,Active Bit SPI[73]" "Inactive,Active"
        bitfld.long 0x00 8. "  AB[72]  ,Active Bit SPI[72]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 7. " AB[71]  ,Active Bit SPI[71]" "Inactive,Active"
        bitfld.long 0x00 6. "  AB[70]  ,Active Bit SPI[70]" "Inactive,Active"
        bitfld.long 0x00 5. "  AB[69]  ,Active Bit SPI[69]" "Inactive,Active"
        bitfld.long 0x00 4. "  AB[68]  ,Active Bit SPI[68]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 3. " AB[67]  ,Active Bit SPI[67]" "Inactive,Active"
        bitfld.long 0x00 2. "  AB[66]  ,Active Bit SPI[66]" "Inactive,Active"
        bitfld.long 0x00 1. "  AB[65]  ,Active Bit SPI[65]" "Inactive,Active"
        bitfld.long 0x00 0. "  AB[64]  ,Active Bit SPI[64]" "Inactive,Active"
rgroup.long 0x310++0x03
    line.long 0x00 "ICDABR4,Active Bit Register 4"
        bitfld.long 0x00 31. " AB[127] ,Active Bit SPI[127]" "Inactive,Active"
        bitfld.long 0x00 30. "  AB[126] ,Active Bit SPI[126]" "Inactive,Active"
        bitfld.long 0x00 29. "  AB[125] ,Active Bit SPI[125]" "Inactive,Active"
        bitfld.long 0x00 28. "  AB[124] ,Active Bit SPI[124]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 27. " AB[123] ,Active Bit SPI[123]" "Inactive,Active"
        bitfld.long 0x00 26. "  AB[122] ,Active Bit SPI[122]" "Inactive,Active"
        bitfld.long 0x00 25. "  AB[121] ,Active Bit SPI[121]" "Inactive,Active"
        bitfld.long 0x00 24. "  AB[120] ,Active Bit SPI[120]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 23. " AB[119] ,Active Bit SPI[119]" "Inactive,Active"
        bitfld.long 0x00 22. "  AB[118] ,Active Bit SPI[118]" "Inactive,Active"
        bitfld.long 0x00 21. "  AB[117] ,Active Bit SPI[117]" "Inactive,Active"
        bitfld.long 0x00 20. "  AB[116] ,Active Bit SPI[116]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 19. " AB[115] ,Active Bit SPI[115]" "Inactive,Active"
        bitfld.long 0x00 18. "  AB[114] ,Active Bit SPI[114]" "Inactive,Active"
        bitfld.long 0x00 17. "  AB[113] ,Active Bit SPI[113]" "Inactive,Active"
        bitfld.long 0x00 16. "  AB[112] ,Active Bit SPI[112]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 15. " AB[111] ,Active Bit SPI[111]" "Inactive,Active"
        bitfld.long 0x00 14. "  AB[110] ,Active Bit SPI[110]" "Inactive,Active"
        bitfld.long 0x00 13. "  AB[109] ,Active Bit SPI[109]" "Inactive,Active"
        bitfld.long 0x00 12. "  AB[108] ,Active Bit SPI[108]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 11. " AB[107] ,Active Bit SPI[107]" "Inactive,Active"
        bitfld.long 0x00 10. "  AB[106] ,Active Bit SPI[106]" "Inactive,Active"
        bitfld.long 0x00 9. "  AB[105] ,Active Bit SPI[105]" "Inactive,Active"
        bitfld.long 0x00 8. "  AB[104] ,Active Bit SPI[104]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 7. " AB[103] ,Active Bit SPI[103]" "Inactive,Active"
        bitfld.long 0x00 6. "  AB[102] ,Active Bit SPI[102]" "Inactive,Active"
        bitfld.long 0x00 5. "  AB[101] ,Active Bit SPI[101]" "Inactive,Active"
        bitfld.long 0x00 4. "  AB[100] ,Active Bit SPI[100]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 3. " AB[99]  ,Active Bit SPI[99]" "Inactive,Active"
        bitfld.long 0x00 2. "  AB[98]  ,Active Bit SPI[98]" "Inactive,Active"
        bitfld.long 0x00 1. "  AB[97]  ,Active Bit SPI[97]" "Inactive,Active"
        bitfld.long 0x00 0. "  AB[96]  ,Active Bit SPI[96]" "Inactive,Active"
rgroup.long 0x314++0x03
    line.long 0x00 "ICDABR5,Active Bit Register 5"    
        bitfld.long 0x00 31. " AB[159] ,Active Bit SPI[159]" "Inactive,Active"
        bitfld.long 0x00 30. "  AB[158] ,Active Bit SPI[158]" "Inactive,Active"
        bitfld.long 0x00 29. "  AB[157] ,Active Bit SPI[157]" "Inactive,Active"
        bitfld.long 0x00 28. "  AB[156] ,Active Bit SPI[156]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 27. " AB[155] ,Active Bit SPI[155]" "Inactive,Active"
        bitfld.long 0x00 26. "  AB[154] ,Active Bit SPI[154]" "Inactive,Active"
        bitfld.long 0x00 25. "  AB[153] ,Active Bit SPI[153]" "Inactive,Active"
        bitfld.long 0x00 24. "  AB[152] ,Active Bit SPI[152]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 23. " AB[151] ,Active Bit SPI[151]" "Inactive,Active"
        bitfld.long 0x00 22. "  AB[150] ,Active Bit SPI[150]" "Inactive,Active"
        bitfld.long 0x00 21. "  AB[149] ,Active Bit SPI[149]" "Inactive,Active"
        bitfld.long 0x00 20. "  AB[148] ,Active Bit SPI[148]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 19. " AB[147] ,Active Bit SPI[147]" "Inactive,Active"
        bitfld.long 0x00 18. "  AB[146] ,Active Bit SPI[146]" "Inactive,Active"
        bitfld.long 0x00 17. "  AB[145] ,Active Bit SPI[145]" "Inactive,Active"
        bitfld.long 0x00 16. "  AB[144] ,Active Bit SPI[144]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 15. " AB[143] ,Active Bit SPI[143]" "Inactive,Active"
        bitfld.long 0x00 14. "  AB[142] ,Active Bit SPI[142]" "Inactive,Active"
        bitfld.long 0x00 13. "  AB[141] ,Active Bit SPI[141]" "Inactive,Active"
        bitfld.long 0x00 12. "  AB[140] ,Active Bit SPI[140]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 11. " AB[139] ,Active Bit SPI[139]" "Inactive,Active"
        bitfld.long 0x00 10. "  AB[138] ,Active Bit SPI[138]" "Inactive,Active"
        bitfld.long 0x00 9. "  AB[137] ,Active Bit SPI[137]" "Inactive,Active"
        bitfld.long 0x00 8. "  AB[136] ,Active Bit SPI[136]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 7. " AB[135] ,Active Bit SPI[135]" "Inactive,Active"
        bitfld.long 0x00 6. "  AB[134] ,Active Bit SPI[134]" "Inactive,Active"
        bitfld.long 0x00 5. "  AB[133] ,Active Bit SPI[133]" "Inactive,Active"
        bitfld.long 0x00 4. "  AB[132] ,Active Bit SPI[132]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 3. " AB[131] ,Active Bit SPI[131]" "Inactive,Active"
        bitfld.long 0x00 2. "  AB[130] ,Active Bit SPI[130]" "Inactive,Active"
        bitfld.long 0x00 1. "  AB[129] ,Active Bit SPI[129]" "Inactive,Active"
        bitfld.long 0x00 0. "  AB[128] ,Active Bit SPI[128]" "Inactive,Active"
rgroup.long 0x318++0x03
    line.long 0x00 "ICDABR6,Active Bit Register 6"        
        bitfld.long 0x00 31. " AB[191] ,Active Bit SPI[191]" "Inactive,Active"
        bitfld.long 0x00 30. "  AB[190] ,Active Bit SPI[190]" "Inactive,Active"
        bitfld.long 0x00 29. "  AB[189] ,Active Bit SPI[189]" "Inactive,Active"
        bitfld.long 0x00 28. "  AB[188] ,Active Bit SPI[188]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 27. " AB[187] ,Active Bit SPI[187]" "Inactive,Active"
        bitfld.long 0x00 26. "  AB[186] ,Active Bit SPI[186]" "Inactive,Active"
        bitfld.long 0x00 25. "  AB[185] ,Active Bit SPI[185]" "Inactive,Active"
        bitfld.long 0x00 24. "  AB[184] ,Active Bit SPI[184]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 23. " AB[183] ,Active Bit SPI[183]" "Inactive,Active"
        bitfld.long 0x00 22. "  AB[182] ,Active Bit SPI[182]" "Inactive,Active"
        bitfld.long 0x00 21. "  AB[181] ,Active Bit SPI[181]" "Inactive,Active"
        bitfld.long 0x00 20. "  AB[180] ,Active Bit SPI[180]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 19. " AB[179] ,Active Bit SPI[179]" "Inactive,Active"
        bitfld.long 0x00 18. "  AB[178] ,Active Bit SPI[178]" "Inactive,Active"
        bitfld.long 0x00 17. "  AB[177] ,Active Bit SPI[177]" "Inactive,Active"
        bitfld.long 0x00 16. "  AB[176] ,Active Bit SPI[176]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 15. " AB[175] ,Active Bit SPI[175]" "Inactive,Active"
        bitfld.long 0x00 14. "  AB[174] ,Active Bit SPI[174]" "Inactive,Active"
        bitfld.long 0x00 13. "  AB[173] ,Active Bit SPI[173]" "Inactive,Active"
        bitfld.long 0x00 12. "  AB[172] ,Active Bit SPI[172]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 11. " AB[171] ,Active Bit SPI[171]" "Inactive,Active"
        bitfld.long 0x00 10. "  AB[170] ,Active Bit SPI[170]" "Inactive,Active"
        bitfld.long 0x00 9. "  AB[169] ,Active Bit SPI[169]" "Inactive,Active"
        bitfld.long 0x00 8. "  AB[168] ,Active Bit SPI[168]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 7. " AB[167] ,Active Bit SPI[167]" "Inactive,Active"
        bitfld.long 0x00 6. "  AB[166] ,Active Bit SPI[166]" "Inactive,Active"
        bitfld.long 0x00 5. "  AB[165] ,Active Bit SPI[165]" "Inactive,Active"
        bitfld.long 0x00 4. "  AB[164] ,Active Bit SPI[164]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 3. " AB[163] ,Active Bit SPI[163]" "Inactive,Active"
        bitfld.long 0x00 2. "  AB[162] ,Active Bit SPI[162]" "Inactive,Active"
        bitfld.long 0x00 1. "  AB[161] ,Active Bit SPI[161]" "Inactive,Active"
        bitfld.long 0x00 0. "  AB[160] ,Active Bit SPI[160]" "Inactive,Active"
rgroup.long 0x31c++0x03
    line.long 0x00 "ICDABR7,Active Bit Register 7"        
        bitfld.long 0x00 31. " AB[223] ,Active Bit SPI[223]" "Inactive,Active"
        bitfld.long 0x00 30. "  AB[222] ,Active Bit SPI[222]" "Inactive,Active"
        bitfld.long 0x00 29. "  AB[221] ,Active Bit SPI[221]" "Inactive,Active"
        bitfld.long 0x00 28. "  AB[220] ,Active Bit SPI[220]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 27. " AB[219] ,Active Bit SPI[219]" "Inactive,Active"
        bitfld.long 0x00 26. "  AB[218] ,Active Bit SPI[218]" "Inactive,Active"
        bitfld.long 0x00 25. "  AB[217] ,Active Bit SPI[217]" "Inactive,Active"
        bitfld.long 0x00 24. "  AB[216] ,Active Bit SPI[216]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 23. " AB[215] ,Active Bit SPI[215]" "Inactive,Active"
        bitfld.long 0x00 22. "  AB[214] ,Active Bit SPI[214]" "Inactive,Active"
        bitfld.long 0x00 21. "  AB[213] ,Active Bit SPI[213]" "Inactive,Active"
        bitfld.long 0x00 20. "  AB[212] ,Active Bit SPI[212]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 19. " AB[211] ,Active Bit SPI[211]" "Inactive,Active"
        bitfld.long 0x00 18. "  AB[210] ,Active Bit SPI[210]" "Inactive,Active"
        bitfld.long 0x00 17. "  AB[209] ,Active Bit SPI[209]" "Inactive,Active"
        bitfld.long 0x00 16. "  AB[208] ,Active Bit SPI[208]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 15. " AB[207] ,Active Bit SPI[207]" "Inactive,Active"
        bitfld.long 0x00 14. "  AB[206] ,Active Bit SPI[206]" "Inactive,Active"
        bitfld.long 0x00 13. "  AB[205] ,Active Bit SPI[205]" "Inactive,Active"
        bitfld.long 0x00 12. "  AB[204] ,Active Bit SPI[204]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 11. " AB[203] ,Active Bit SPI[203]" "Inactive,Active"
        bitfld.long 0x00 10. "  AB[202] ,Active Bit SPI[202]" "Inactive,Active"
        bitfld.long 0x00 9. "  AB[201] ,Active Bit SPI[201]" "Inactive,Active"
        bitfld.long 0x00 8. "  AB[200] ,Active Bit SPI[200]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 7. " AB[199] ,Active Bit SPI[199]" "Inactive,Active"
        bitfld.long 0x00 6. "  AB[198] ,Active Bit SPI[198]" "Inactive,Active"
        bitfld.long 0x00 5. "  AB[197] ,Active Bit SPI[197]" "Inactive,Active"
        bitfld.long 0x00 4. "  AB[196] ,Active Bit SPI[196]" "Inactive,Active"
        textline "                  "
        bitfld.long 0x00 3. " AB[195] ,Active Bit SPI[195]" "Inactive,Active"
        bitfld.long 0x00 2. "  AB[194] ,Active Bit SPI[194]" "Inactive,Active"
        bitfld.long 0x00 1. "  AB[193] ,Active Bit SPI[193]" "Inactive,Active"
        bitfld.long 0x00 0. "  AB[192] ,Active Bit SPI[192]" "Inactive,Active"
tree.end
width 10.
tree "Interrrupt Priority Registers"
group.long 0x400++0x03
    line.long 0x00 "ICDIPR0,Interrupt Priority Register 0"
        bitfld.long 0x00 27.--31. " IPS[3]   ,Interrupt Priority STI[3]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IPS[2]   ,Interrupt Priority STI[2]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IPS[1]   ,Interrupt Priority STI[1]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IPS[0]   ,Interrupt Priority STI[0]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x404++0x03
    line.long 0x00 "ICDIPR1,Interrupt Priority Register 1"
        bitfld.long 0x00 27.--31. " IPS[7]   ,Interrupt Priority STI[7]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IPS[6]   ,Interrupt Priority STI[6]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IPS[5]   ,Interrupt Priority STI[5]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IPS[4]   ,Interrupt Priority STI[4]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x408++0x03
    line.long 0x00 "ICDIPR2,Interrupt Priority Register 2"
        bitfld.long 0x00 27.--31. " IPS[11]  ,Interrupt Priority STI[11]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IPS[10]  ,Interrupt Priority STI[10]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IPS[9]   ,Interrupt Priority STI[9]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IPS[8]   ,Interrupt Priority STI[8]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"        
group.long 0x40c++0x03
    line.long 0x00 "ICDIPR3,Interrupt Priority Register 3"
        bitfld.long 0x00 27.--31. " IPS[15]  ,Interrupt Priority STI[15]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IPS[14]  ,Interrupt Priority STI[14]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IPS[13]  ,Interrupt Priority STI[13]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IPS[12]  ,Interrupt Priority STI[12]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"                
group.long 0x418++0x3
    line.long 0x00 "ICDIPR6,Interrupt Priority Register 7"
        bitfld.long 0x00 27.--31. " IPP[4]   ,Interrupt Priority PPI[4]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x41c++0x03
    line.long 0x00 "ICDIPR7,Interrupt Priority Register 7"
        bitfld.long 0x00 27.--31. " IPP[3]   ,Interrupt Priority PPI[3]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IPP[2]   ,Interrupt Priority PPI[2]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IPP[1]   ,Interrupt Priority PPI[1]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IPP[0]   ,Interrupt Priority PPI[0]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"                

group.long 0x420++0x03
    line.long 0x00 "ICDIPR8,Interrupt Priority Register 8"
        bitfld.long 0x00 27.--31. " IP[3]    ,Interrupt Priority SPI[3]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[2]    ,Interrupt Priority SPI[2]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[1]    ,Interrupt Priority SPI[1]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[0]    ,Interrupt Priority SPI[0]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x424++0x03
    line.long 0x00 "ICDIPR9,Interrupt Priority Register 9"
        bitfld.long 0x00 27.--31. " IP[7]    ,Interrupt Priority SPI[7]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[6]    ,Interrupt Priority SPI[6]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[5]    ,Interrupt Priority SPI[5]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[4]    ,Interrupt Priority SPI[4]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x428++0x03
    line.long 0x00 "ICDIPR10,Interrupt Priority Register 10"
        bitfld.long 0x00 27.--31. " IP[11]   ,Interrupt Priority SPI[11]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[10]   ,Interrupt Priority SPI[10]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[9]    ,Interrupt Priority SPI[9]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[8]    ,Interrupt Priority SPI[8]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x42C++0x03
    line.long 0x00 "ICDIPR11,Interrupt Priority Register 11"
        bitfld.long 0x00 27.--31. " IP[15]   ,Interrupt Priority SPI[15]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[14]   ,Interrupt Priority SPI[14]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[13]   ,Interrupt Priority SPI[13]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[12]   ,Interrupt Priority SPI[12]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x430++0x03
    line.long 0x00 "ICDIPR12,Interrupt Priority Register 12"
        bitfld.long 0x00 27.--31. " IP[19]   ,Interrupt Priority SPI[19]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[18]   ,Interrupt Priority SPI[18]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[17]   ,Interrupt Priority SPI[17]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[16]   ,Interrupt Priority SPI[16]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x434++0x03
    line.long 0x00 "ICDIPR13,Interrupt Priority Register 13"
        bitfld.long 0x00 27.--31. " IP[23]   ,Interrupt Priority SPI[23]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[22]   ,Interrupt Priority SPI[22]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[21]   ,Interrupt Priority SPI[21]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[20]   ,Interrupt Priority SPI[20]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x438++0x03
    line.long 0x00 "ICDIPR14,Interrupt Priority Register 14"
        bitfld.long 0x00 27.--31. " IP[27]   ,Interrupt Priority SPI[27]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[26]   ,Interrupt Priority SPI[26]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[25]   ,Interrupt Priority SPI[25]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[24]   ,Interrupt Priority SPI[24]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x43C++0x03
    line.long 0x00 "ICDIPR15,Interrupt Priority Register 15"
        bitfld.long 0x00 27.--31. " IP[31]   ,Interrupt Priority SPI[31]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[30]   ,Interrupt Priority SPI[30]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[29]   ,Interrupt Priority SPI[29]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[28]   ,Interrupt Priority SPI[28]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x440++0x03
    line.long 0x00 "ICDIPR16,Interrupt Priority Register 16"
        bitfld.long 0x00 27.--31. " IP[35]   ,Interrupt Priority SPI[35]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[34]   ,Interrupt Priority SPI[34]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[33]   ,Interrupt Priority SPI[33]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[32]   ,Interrupt Priority SPI[32]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x444++0x03
    line.long 0x00 "ICDIPR17,Interrupt Priority Register 17"
        bitfld.long 0x00 27.--31. " IP[39]   ,Interrupt Priority SPI[39]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[38]   ,Interrupt Priority SPI[38]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[37]   ,Interrupt Priority SPI[37]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[36]   ,Interrupt Priority SPI[36]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x448++0x03
    line.long 0x00 "ICDIPR18,Interrupt Priority Register 18"
        bitfld.long 0x00 27.--31. " IP[43]   ,Interrupt Priority SPI[43]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[42]   ,Interrupt Priority SPI[42]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[41]   ,Interrupt Priority SPI[41]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[40]   ,Interrupt Priority SPI[40]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x44C++0x03
    line.long 0x00 "ICDIPR19,Interrupt Priority Register 19"
        bitfld.long 0x00 27.--31. " IP[47]   ,Interrupt Priority SPI[47]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[46]   ,Interrupt Priority SPI[46]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[45]   ,Interrupt Priority SPI[45]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[44]   ,Interrupt Priority SPI[44]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x450++0x03
    line.long 0x00 "ICDIPR20,Interrupt Priority Register 20"
        bitfld.long 0x00 27.--31. " IP[51]   ,Interrupt Priority SPI[51]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[50]   ,Interrupt Priority SPI[50]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[49]   ,Interrupt Priority SPI[49]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[48]   ,Interrupt Priority SPI[48]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x454++0x03
    line.long 0x00 "ICDIPR21,Interrupt Priority Register 21"
        bitfld.long 0x00 27.--31. " IP[55]   ,Interrupt Priority SPI[55]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[54]   ,Interrupt Priority SPI[54]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[53]   ,Interrupt Priority SPI[53]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[52]   ,Interrupt Priority SPI[52]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x458++0x03
    line.long 0x00 "ICDIPR22,Interrupt Priority Register 22"
        bitfld.long 0x00 27.--31. " IP[59]   ,Interrupt Priority SPI[59]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[58]   ,Interrupt Priority SPI[58]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[57]   ,Interrupt Priority SPI[57]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[56]   ,Interrupt Priority SPI[56]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x45C++0x03
    line.long 0x00 "ICDIPR23,Interrupt Priority Register 23"
        bitfld.long 0x00 27.--31. " IP[63]   ,Interrupt Priority SPI[63]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[62]   ,Interrupt Priority SPI[62]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[61]   ,Interrupt Priority SPI[61]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[60]   ,Interrupt Priority SPI[60]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x460++0x03
    line.long 0x00 "ICDIPR24,Interrupt Priority Register 24"
        bitfld.long 0x00 27.--31. " IP[67]   ,Interrupt Priority SPI[67]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[66]   ,Interrupt Priority SPI[66]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[65]   ,Interrupt Priority SPI[65]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[64]   ,Interrupt Priority SPI[64]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x464++0x03
    line.long 0x00 "ICDIPR25,Interrupt Priority Register 25"
        bitfld.long 0x00 27.--31. " IP[103]  ,Interrupt Priority SPI[103]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[102]  ,Interrupt Priority SPI[102]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[101]  ,Interrupt Priority SPI[101]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[100]  ,Interrupt Priority SPI[100]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x468++0x03
    line.long 0x00 "ICDIPR26,Interrupt Priority Register 26"
        bitfld.long 0x00 27.--31. " IP[107]  ,Interrupt Priority SPI[107]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[106]  ,Interrupt Priority SPI[106]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[105]  ,Interrupt Priority SPI[105]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[104]  ,Interrupt Priority SPI[104]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x46C++0x03
    line.long 0x00 "ICDIPR27,Interrupt Priority Register 27"
        bitfld.long 0x00 27.--31. " IP[111]  ,Interrupt Priority SPI[111]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[110]  ,Interrupt Priority SPI[110]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[109]  ,Interrupt Priority SPI[109]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[108]  ,Interrupt Priority SPI[108]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x470++0x03
    line.long 0x00 "ICDIPR28,Interrupt Priority Register 28"
        bitfld.long 0x00 27.--31. " IP[115]  ,Interrupt Priority SPI[115]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[114]  ,Interrupt Priority SPI[114]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[113]  ,Interrupt Priority SPI[113]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[112]  ,Interrupt Priority SPI[112]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x474++0x03
    line.long 0x00 "ICDIPR29,Interrupt Priority Register 29"
        bitfld.long 0x00 27.--31. " IP[119]  ,Interrupt Priority SPI[119]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[118]  ,Interrupt Priority SPI[118]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[117]  ,Interrupt Priority SPI[117]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[116]  ,Interrupt Priority SPI[116]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x478++0x03
    line.long 0x00 "ICDIPR30,Interrupt Priority Register 30"
        bitfld.long 0x00 27.--31. " IP[123]  ,Interrupt Priority SPI[123]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[122]  ,Interrupt Priority SPI[122]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[121]  ,Interrupt Priority SPI[121]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[120]  ,Interrupt Priority SPI[120]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x47C++0x03
    line.long 0x00 "ICDIPR31,Interrupt Priority Register 31"
        bitfld.long 0x00 27.--31. " IP[127]  ,Interrupt Priority SPI[127]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[126]  ,Interrupt Priority SPI[126]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[125]  ,Interrupt Priority SPI[125]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[124]  ,Interrupt Priority SPI[124]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x480++0x03
    line.long 0x00 "ICDIPR32,Interrupt Priority Register 32"
        bitfld.long 0x00 27.--31. " IP[131]  ,Interrupt Priority SPI[131]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[130]  ,Interrupt Priority SPI[130]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[129]  ,Interrupt Priority SPI[129]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[128]  ,Interrupt Priority SPI[128]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x484++0x03
    line.long 0x00 "ICDIPR33,Interrupt Priority Register 33"
        bitfld.long 0x00 27.--31. " IP[135]  ,Interrupt Priority SPI[135]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[134]  ,Interrupt Priority SPI[134]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[133]  ,Interrupt Priority SPI[133]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[132]  ,Interrupt Priority SPI[132]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x488++0x03
    line.long 0x00 "ICDIPR34,Interrupt Priority Register 34"
        bitfld.long 0x00 27.--31. " IP[139]  ,Interrupt Priority SPI[139]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[138]  ,Interrupt Priority SPI[138]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[137]  ,Interrupt Priority SPI[137]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[136]  ,Interrupt Priority SPI[136]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x48C++0x03
    line.long 0x00 "ICDIPR35,Interrupt Priority Register 35"
        bitfld.long 0x00 27.--31. " IP[143]  ,Interrupt Priority SPI[143]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[142]  ,Interrupt Priority SPI[142]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[141]  ,Interrupt Priority SPI[141]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[140]  ,Interrupt Priority SPI[140]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x490++0x03
    line.long 0x00 "ICDIPR36,Interrupt Priority Register 36"
        bitfld.long 0x00 27.--31. " IP[147]  ,Interrupt Priority SPI[147]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[146]  ,Interrupt Priority SPI[146]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[145]  ,Interrupt Priority SPI[145]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[144]  ,Interrupt Priority SPI[144]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x494++0x03
    line.long 0x00 "ICDIPR37,Interrupt Priority Register 37"
        bitfld.long 0x00 27.--31. " IP[151]  ,Interrupt Priority SPI[151]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[150]  ,Interrupt Priority SPI[150]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[149]  ,Interrupt Priority SPI[149]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[148]  ,Interrupt Priority SPI[148]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x498++0x03
    line.long 0x00 "ICDIPR38,Interrupt Priority Register 38"
        bitfld.long 0x00 27.--31. " IP[155]  ,Interrupt Priority SPI[155]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[154]  ,Interrupt Priority SPI[154]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[153]  ,Interrupt Priority SPI[153]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[152]  ,Interrupt Priority SPI[152]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x49C++0x03
    line.long 0x00 "ICDIPR39,Interrupt Priority Register 39"
        bitfld.long 0x00 27.--31. " IP[159]  ,Interrupt Priority SPI[159]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[158]  ,Interrupt Priority SPI[158]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[157]  ,Interrupt Priority SPI[157]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[156]  ,Interrupt Priority SPI[156]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4A0++0x03
    line.long 0x00 "ICDIPR40,Interrupt Priority Register 40"
        bitfld.long 0x00 27.--31. " IP[163]  ,Interrupt Priority SPI[163]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[162]  ,Interrupt Priority SPI[162]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[161]  ,Interrupt Priority SPI[161]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[160]  ,Interrupt Priority SPI[160]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4A4++0x03
    line.long 0x00 "ICDIPR41,Interrupt Priority Register 41"
        bitfld.long 0x00 27.--31. " IP[167]  ,Interrupt Priority SPI[167]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[166]  ,Interrupt Priority SPI[166]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[165]  ,Interrupt Priority SPI[165]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[164]  ,Interrupt Priority SPI[164]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4A8++0x03
    line.long 0x00 "ICDIPR42,Interrupt Priority Register 42"
        bitfld.long 0x00 27.--31. " IP[171]  ,Interrupt Priority SPI[171]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[170]  ,Interrupt Priority SPI[170]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[169]  ,Interrupt Priority SPI[169]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[168]  ,Interrupt Priority SPI[168]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4AC++0x03
    line.long 0x00 "ICDIPR43,Interrupt Priority Register 43"
        bitfld.long 0x00 27.--31. " IP[175]  ,Interrupt Priority SPI[175]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[174]  ,Interrupt Priority SPI[174]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[173]  ,Interrupt Priority SPI[173]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[172]  ,Interrupt Priority SPI[172]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4B0++0x03
    line.long 0x00 "ICDIPR44,Interrupt Priority Register 44"
        bitfld.long 0x00 27.--31. " IP[179]  ,Interrupt Priority SPI[179]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[178]  ,Interrupt Priority SPI[178]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[177]  ,Interrupt Priority SPI[177]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[176]  ,Interrupt Priority SPI[176]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4B4++0x03
    line.long 0x00 "ICDIPR45,Interrupt Priority Register 45"
        bitfld.long 0x00 27.--31. " IP[183]  ,Interrupt Priority SPI[183]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[182]  ,Interrupt Priority SPI[182]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[181]  ,Interrupt Priority SPI[181]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[180]  ,Interrupt Priority SPI[180]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4B8++0x03
    line.long 0x00 "ICDIPR46,Interrupt Priority Register 46"
        bitfld.long 0x00 27.--31. " IP[187]  ,Interrupt Priority SPI[187]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[186]  ,Interrupt Priority SPI[186]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[185]  ,Interrupt Priority SPI[185]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[184]  ,Interrupt Priority SPI[184]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4BC++0x03
    line.long 0x00 "ICDIPR47,Interrupt Priority Register 47"
        bitfld.long 0x00 27.--31. " IP[191]  ,Interrupt Priority SPI[191]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[190]  ,Interrupt Priority SPI[190]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[189]  ,Interrupt Priority SPI[189]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[188]  ,Interrupt Priority SPI[188]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4C0++0x03
    line.long 0x00 "ICDIPR48,Interrupt Priority Register 48"
        bitfld.long 0x00 27.--31. " IP[195]  ,Interrupt Priority SPI[195]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[194]  ,Interrupt Priority SPI[194]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[193]  ,Interrupt Priority SPI[193]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[192]  ,Interrupt Priority SPI[192]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4C4++0x03
    line.long 0x00 "ICDIPR49,Interrupt Priority Register 49"
        bitfld.long 0x00 27.--31. " IP[199]  ,Interrupt Priority SPI[199]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[198]  ,Interrupt Priority SPI[198]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[197]  ,Interrupt Priority SPI[197]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[196]  ,Interrupt Priority SPI[196]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4C8++0x03
    line.long 0x00 "ICDIPR50,Interrupt Priority Register 50"
        bitfld.long 0x00 27.--31. " IP[203]  ,Interrupt Priority SPI[203]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[202]  ,Interrupt Priority SPI[202]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[201]  ,Interrupt Priority SPI[201]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[200]  ,Interrupt Priority SPI[200]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4CC++0x03
    line.long 0x00 "ICDIPR51,Interrupt Priority Register 51"
        bitfld.long 0x00 27.--31. " IP[207]  ,Interrupt Priority SPI[207]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[206]  ,Interrupt Priority SPI[206]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[205]  ,Interrupt Priority SPI[205]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[204]  ,Interrupt Priority SPI[204]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4D0++0x03
    line.long 0x00 "ICDIPR52,Interrupt Priority Register 52"
        bitfld.long 0x00 27.--31. " IP[211]  ,Interrupt Priority SPI[211]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[210]  ,Interrupt Priority SPI[210]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[209]  ,Interrupt Priority SPI[209]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[208]  ,Interrupt Priority SPI[208]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4D4++0x03
    line.long 0x00 "ICDIPR53,Interrupt Priority Register 53"
        bitfld.long 0x00 27.--31. " IP[215]  ,Interrupt Priority SPI[215]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[214]  ,Interrupt Priority SPI[214]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[213]  ,Interrupt Priority SPI[213]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[212]  ,Interrupt Priority SPI[212]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4D8++0x03
    line.long 0x00 "ICDIPR54,Interrupt Priority Register 54"
        bitfld.long 0x00 27.--31. " IP[219]  ,Interrupt Priority SPI[219]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[218]  ,Interrupt Priority SPI[218]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[217]  ,Interrupt Priority SPI[217]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[216]  ,Interrupt Priority SPI[216]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4DC++0x03
    line.long 0x00 "ICDIPR55,Interrupt Priority Register 55"
        bitfld.long 0x00 27.--31. " IP[223]  ,Interrupt Priority SPI[223]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[222]  ,Interrupt Priority SPI[222]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[221]  ,Interrupt Priority SPI[221]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[220]  ,Interrupt Priority SPI[220]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4E0++0x03
    line.long 0x00 "ICDIPR56,Interrupt Priority Register 56"
        bitfld.long 0x00 27.--31. " IP[227]  ,Interrupt Priority SPI[227]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[226]  ,Interrupt Priority SPI[226]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[225]  ,Interrupt Priority SPI[225]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[224]  ,Interrupt Priority SPI[224]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4E4++0x03
    line.long 0x00 "ICDIPR57,Interrupt Priority Register 57"
        bitfld.long 0x00 27.--31. " IP[231]  ,Interrupt Priority SPI[231]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[230]  ,Interrupt Priority SPI[230]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[229]  ,Interrupt Priority SPI[229]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[228]  ,Interrupt Priority SPI[228]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4E8++0x03
    line.long 0x00 "ICDIPR58,Interrupt Priority Register 58"
        bitfld.long 0x00 27.--31. " IP[235]  ,Interrupt Priority SPI[235]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[234]  ,Interrupt Priority SPI[234]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[233]  ,Interrupt Priority SPI[233]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[232]  ,Interrupt Priority SPI[232]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4EC++0x03
    line.long 0x00 "ICDIPR59,Interrupt Priority Register 59"
        bitfld.long 0x00 27.--31. " IP[239]  ,Interrupt Priority SPI[239]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[238]  ,Interrupt Priority SPI[238]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[237]  ,Interrupt Priority SPI[237]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[236]  ,Interrupt Priority SPI[236]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4F0++0x03
    line.long 0x00 "ICDIPR60,Interrupt Priority Register 60"
        bitfld.long 0x00 27.--31. " IP[243]  ,Interrupt Priority SPI[243]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[242]  ,Interrupt Priority SPI[242]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[241]  ,Interrupt Priority SPI[241]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[240]  ,Interrupt Priority SPI[240]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4F4++0x03
    line.long 0x00 "ICDIPR61,Interrupt Priority Register 61"
        bitfld.long 0x00 27.--31. " IP[247]  ,Interrupt Priority SPI[247]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[246]  ,Interrupt Priority SPI[246]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[245]  ,Interrupt Priority SPI[245]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[244]  ,Interrupt Priority SPI[244]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4F8++0x03
    line.long 0x00 "ICDIPR62,Interrupt Priority Register 62"
        bitfld.long 0x00 27.--31. " IP[251]  ,Interrupt Priority SPI[251]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[250]  ,Interrupt Priority SPI[250]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[249]  ,Interrupt Priority SPI[249]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[248]  ,Interrupt Priority SPI[248]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
group.long 0x4FC++0x03
    line.long 0x00 "ICDIPR63,Interrupt Priority Register 63"
        bitfld.long 0x00 27.--31. " IP[255]  ,Interrupt Priority SPI[255]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 19.--23. "  IP[254]  ,Interrupt Priority SPI[254]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 11.--15. "  IP[253]  ,Interrupt Priority SPI[253]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
        bitfld.long 0x00 3.--7. "  IP[252]  ,Interrupt Priority SPI[252]" "Highest,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Lowest"
tree.end
width 12.
tree "SPI Target Registers"
group.long 0x800++0x03
    line.long 0x00 "ICDIPTR0,Interrupt SPI Target Register 0"
        bitfld.long 0x00 27. " IT3[3]    ,Interrupt Target 3 CPU3" "0,1"
        bitfld.long 0x00 26. "  IT3[2]    ,Interrupt Target 3 CPU2" "0,1"
        bitfld.long 0x00 25. "  IT3[1]    ,Interrupt Target 3 CPU1" "0,1"
        bitfld.long 0x00 24. "  IT3[0]    ,Interrupt Target 3 CPU0" "0,1"
        bitfld.long 0x00 19. "  IT2[3]   ,Interrupt Target 2 CPU3" "0,1"
        bitfld.long 0x00 18. "  IT2[2]   ,Interrupt Target 2 CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT2[1]    ,Interrupt Target 2 CPU1" "0,1"
        bitfld.long 0x00 16. "  IT2[0]    ,Interrupt Target 2 CPU0" "0,1"
        bitfld.long 0x00 11. "  IT1[3]    ,Interrupt Target 1 CPU3" "0,1"
        bitfld.long 0x00 10. "  IT1[2]    ,Interrupt Target 1 CPU2" "0,1"
        bitfld.long 0x00 9. "  IT1[1]   ,Interrupt Target 1 CPU1" "0,1"
        bitfld.long 0x00 8. "  IT1[0]   ,Interrupt Target 1 CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT0[3]    ,Interrupt Target 0 CPU3" "0,1"
        bitfld.long 0x00 2. "  IT0[2]    ,Interrupt Target 0 CPU2" "0,1"
        bitfld.long 0x00 1. "  IT0[1]    ,Interrupt Target 0 CPU1" "0,1"
        bitfld.long 0x00 0. "  IT0[0]    ,Interrupt Target 0 CPU0" "0,1"
group.long 0x804++0x03
    line.long 0x00 "ICDIPTR1,Interrupt SPI Target Register 1"
        bitfld.long 0x00 27. " IT7[3]    ,Interrupt Target 7 CPU3" "0,1"
        bitfld.long 0x00 26. "  IT7[2]    ,Interrupt Target 7 CPU2" "0,1"
        bitfld.long 0x00 25. "  IT7[1]    ,Interrupt Target 7 CPU1" "0,1"
        bitfld.long 0x00 24. "  IT7[0]    ,Interrupt Target 7 CPU0" "0,1"
        bitfld.long 0x00 19. "  IT6[3]   ,Interrupt Target 6 CPU3" "0,1"
        bitfld.long 0x00 18. "  IT6[2]   ,Interrupt Target 6 CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT6[1]    ,Interrupt Target 6 CPU1" "0,1"
        bitfld.long 0x00 16. "  IT6[0]    ,Interrupt Target 6 CPU0" "0,1"
        bitfld.long 0x00 11. "  IT5[3]    ,Interrupt Target 5 CPU3" "0,1"
        bitfld.long 0x00 10. "  IT5[2]    ,Interrupt Target 5 CPU2" "0,1"
        bitfld.long 0x00 9. "  IT5[1]   ,Interrupt Target 5 CPU1" "0,1"
        bitfld.long 0x00 8. "  IT5[0]   ,Interrupt Target 5 CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT4[3]    ,Interrupt Target 4 CPU3" "0,1"
        bitfld.long 0x00 2. "  IT4[2]    ,Interrupt Target 4 CPU2" "0,1"
        bitfld.long 0x00 1. "  IT4[1]    ,Interrupt Target 4 CPU1" "0,1"
        bitfld.long 0x00 0. "  IT4[0]    ,Interrupt Target 4 CPU0" "0,1"
group.long 0x808++0x03
    line.long 0x00 "ICDIPTR2,Interrupt SPI Target Register 2"
        bitfld.long 0x00 27. " IT11[3]   ,Interrupt Target 11 CPU3" "0,1"
        bitfld.long 0x00 26. "  IT11[2]   ,Interrupt Target 11 CPU2" "0,1"
        bitfld.long 0x00 25. "  IT11[1]   ,Interrupt Target 11 CPU1" "0,1"
        bitfld.long 0x00 24. "  IT11[0]   ,Interrupt Target 11 CPU0" "0,1"
        bitfld.long 0x00 19. "  IT10[3]  ,Interrupt Target 10 CPU3" "0,1"
        bitfld.long 0x00 18. "  IT10[2]  ,Interrupt Target 10 CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT10[1]   ,Interrupt Target 10 CPU1" "0,1"
        bitfld.long 0x00 16. "  IT10[0]   ,Interrupt Target 10 CPU0" "0,1"
        bitfld.long 0x00 11. "  IT9[3]    ,Interrupt Target 9 CPU3" "0,1"
        bitfld.long 0x00 10. "  IT9[2]    ,Interrupt Target 9 CPU2" "0,1"
        bitfld.long 0x00 9. "  IT9[1]   ,Interrupt Target 9 CPU1" "0,1"
        bitfld.long 0x00 8. "  IT9[0]   ,Interrupt Target 9 CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT8[3]    ,Interrupt Target 8 CPU3" "0,1"
        bitfld.long 0x00 2. "  IT8[2]    ,Interrupt Target 8 CPU2" "0,1"
        bitfld.long 0x00 1. "  IT8[1]    ,Interrupt Target 8 CPU1" "0,1"
        bitfld.long 0x00 0. "  IT8[0]    ,Interrupt Target 8 CPU0" "0,1"
group.long 0x80C++0x03
    line.long 0x00 "ICDIPTR3,Interrupt SPI Target Register 3"
        bitfld.long 0x00 27. " IT15[3]   ,Interrupt Target 15 CPU3" "0,1"
        bitfld.long 0x00 26. "  IT15[2]   ,Interrupt Target 15 CPU2" "0,1"
        bitfld.long 0x00 25. "  IT15[1]   ,Interrupt Target 15 CPU1" "0,1"
        bitfld.long 0x00 24. "  IT15[0]   ,Interrupt Target 15 CPU0" "0,1"
        bitfld.long 0x00 19. "  IT14[3]  ,Interrupt Target 14 CPU3" "0,1"
        bitfld.long 0x00 18. "  IT14[2]  ,Interrupt Target 14 CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT14[1]   ,Interrupt Target 14 CPU1" "0,1"
        bitfld.long 0x00 16. "  IT14[0]   ,Interrupt Target 14 CPU0" "0,1"
        bitfld.long 0x00 11. "  IT13[3]   ,Interrupt Target 13 CPU3" "0,1"
        bitfld.long 0x00 10. "  IT13[2]   ,Interrupt Target 13 CPU2" "0,1"
        bitfld.long 0x00 9. "  IT13[1]  ,Interrupt Target 13 CPU1" "0,1"
        bitfld.long 0x00 8. "  IT13[0]  ,Interrupt Target 13 CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT12[3]   ,Interrupt Target 12 CPU3" "0,1"
        bitfld.long 0x00 2. "  IT12[2]   ,Interrupt Target 12 CPU2" "0,1"
        bitfld.long 0x00 1. "  IT12[1]   ,Interrupt Target 12 CPU1" "0,1"
        bitfld.long 0x00 0. "  IT12[0]   ,Interrupt Target 12 CPU0" "0,1"
group.long 0x810++0x03
    line.long 0x00 "ICDIPTR4,Interrupt SPI Target Register 4"
        bitfld.long 0x00 27. " IT19[3]   ,Interrupt Target 19 CPU3" "0,1"
        bitfld.long 0x00 26. "  IT19[2]   ,Interrupt Target 19 CPU2" "0,1"
        bitfld.long 0x00 25. "  IT19[1]   ,Interrupt Target 19 CPU1" "0,1"
        bitfld.long 0x00 24. "  IT19[0]   ,Interrupt Target 19 CPU0" "0,1"
        bitfld.long 0x00 19. "  IT18[3]  ,Interrupt Target 18 CPU3" "0,1"
        bitfld.long 0x00 18. "  IT18[2]  ,Interrupt Target 18 CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT18[1]   ,Interrupt Target 18 CPU1" "0,1"
        bitfld.long 0x00 16. "  IT18[0]   ,Interrupt Target 18 CPU0" "0,1"
        bitfld.long 0x00 11. "  IT17[3]   ,Interrupt Target 17 CPU3" "0,1"
        bitfld.long 0x00 10. "  IT17[2]   ,Interrupt Target 17 CPU2" "0,1"
        bitfld.long 0x00 9. "  IT17[1]  ,Interrupt Target 17 CPU1" "0,1"
        bitfld.long 0x00 8. "  IT17[0]  ,Interrupt Target 17 CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT16[3]   ,Interrupt Target 16 CPU3" "0,1"
        bitfld.long 0x00 2. "  IT16[2]   ,Interrupt Target 16 CPU2" "0,1"
        bitfld.long 0x00 1. "  IT16[1]   ,Interrupt Target 16 CPU1" "0,1"
        bitfld.long 0x00 0. "  IT16[0]   ,Interrupt Target 16 CPU0" "0,1"
group.long 0x814++0x03
    line.long 0x00 "ICDIPTR5,Interrupt SPI Target Register 5"
        bitfld.long 0x00 27. " IT23[3]   ,Interrupt Target 23 CPU3" "0,1"
        bitfld.long 0x00 26. "  IT23[2]   ,Interrupt Target 23 CPU2" "0,1"
        bitfld.long 0x00 25. "  IT23[1]   ,Interrupt Target 23 CPU1" "0,1"
        bitfld.long 0x00 24. "  IT23[0]   ,Interrupt Target 23 CPU0" "0,1"
        bitfld.long 0x00 19. "  IT22[3]  ,Interrupt Target 22 CPU3" "0,1"
        bitfld.long 0x00 18. "  IT22[2]  ,Interrupt Target 22 CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT22[1]   ,Interrupt Target 22 CPU1" "0,1"
        bitfld.long 0x00 16. "  IT22[0]   ,Interrupt Target 22 CPU0" "0,1"
        bitfld.long 0x00 11. "  IT21[3]   ,Interrupt Target 21 CPU3" "0,1"
        bitfld.long 0x00 10. "  IT21[2]   ,Interrupt Target 21 CPU2" "0,1"
        bitfld.long 0x00 9. "  IT21[1]  ,Interrupt Target 21 CPU1" "0,1"
        bitfld.long 0x00 8. "  IT21[0]  ,Interrupt Target 21 CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT20[3]   ,Interrupt Target 20 CPU3" "0,1"
        bitfld.long 0x00 2. "  IT20[2]   ,Interrupt Target 20 CPU2" "0,1"
        bitfld.long 0x00 1. "  IT20[1]   ,Interrupt Target 20 CPU1" "0,1"
        bitfld.long 0x00 0. "  IT20[0]   ,Interrupt Target 20 CPU0" "0,1"
group.long 0x818++0x03
    line.long 0x00 "ICDIPTR6,Interrupt SPI Target Register 6"
        bitfld.long 0x00 27. " IT27[3]   ,Interrupt Target 27 CPU3" "0,1"
        bitfld.long 0x00 26. "  IT27[2]   ,Interrupt Target 27 CPU2" "0,1"
        bitfld.long 0x00 25. "  IT27[1]   ,Interrupt Target 27 CPU1" "0,1"
        bitfld.long 0x00 24. "  IT27[0]   ,Interrupt Target 27 CPU0" "0,1"
        bitfld.long 0x00 19. "  IT26[3]  ,Interrupt Target 26 CPU3" "0,1"
        bitfld.long 0x00 18. "  IT26[2]  ,Interrupt Target 26 CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT26[1]   ,Interrupt Target 26 CPU1" "0,1"
        bitfld.long 0x00 16. "  IT26[0]   ,Interrupt Target 26 CPU0" "0,1"
        bitfld.long 0x00 11. "  IT25[3]   ,Interrupt Target 25 CPU3" "0,1"
        bitfld.long 0x00 10. "  IT25[2]   ,Interrupt Target 25 CPU2" "0,1"
        bitfld.long 0x00 9. "  IT25[1]  ,Interrupt Target 25 CPU1" "0,1"
        bitfld.long 0x00 8. "  IT25[0]  ,Interrupt Target 25 CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT24[3]   ,Interrupt Target 24 CPU3" "0,1"
        bitfld.long 0x00 2. "  IT24[2]   ,Interrupt Target 24 CPU2" "0,1"
        bitfld.long 0x00 1. "  IT24[1]   ,Interrupt Target 24 CPU1" "0,1"
        bitfld.long 0x00 0. "  IT24[0]   ,Interrupt Target 24 CPU0" "0,1"
group.long 0x81C++0x03
    line.long 0x00 "ICDIPTR7,Interrupt SPI Target Register 7"
        bitfld.long 0x00 27. " IT31[3]   ,Interrupt Target 31 CPU3" "0,1"
        bitfld.long 0x00 26. "  IT31[2]   ,Interrupt Target 31 CPU2" "0,1"
        bitfld.long 0x00 25. "  IT31[1]   ,Interrupt Target 31 CPU1" "0,1"
        bitfld.long 0x00 24. "  IT31[0]   ,Interrupt Target 31 CPU0" "0,1"
        bitfld.long 0x00 19. "  IT30[3]  ,Interrupt Target 30 CPU3" "0,1"
        bitfld.long 0x00 18. "  IT30[2]  ,Interrupt Target 30 CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT30[1]   ,Interrupt Target 30 CPU1" "0,1"
        bitfld.long 0x00 16. "  IT30[0]   ,Interrupt Target 30 CPU0" "0,1"
        bitfld.long 0x00 11. "  IT29[3]   ,Interrupt Target 29 CPU3" "0,1"
        bitfld.long 0x00 10. "  IT29[2]   ,Interrupt Target 29 CPU2" "0,1"
        bitfld.long 0x00 9. "  IT29[1]  ,Interrupt Target 29 CPU1" "0,1"
        bitfld.long 0x00 8. "  IT29[0]  ,Interrupt Target 29 CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT28[3]   ,Interrupt Target 28 CPU3" "0,1"
        bitfld.long 0x00 2. "  IT28[2]   ,Interrupt Target 28 CPU2" "0,1"
        bitfld.long 0x00 1. "  IT28[1]   ,Interrupt Target 28 CPU1" "0,1"
        bitfld.long 0x00 0. "  IT28[0]   ,Interrupt Target 28 CPU0" "0,1"
group.long 0x820++0x03
    line.long 0x00 "ICDIPTR8,Interrupt SPI Target Register 8"
        bitfld.long 0x00 27. " IT35[3]   ,Interrupt Target 35 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT35[2]   ,Interrupt Target 35 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT35[1]   ,Interrupt Target 35 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT35[0]   ,Interrupt Target 35 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT34[3]  ,Interrupt Target 34 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT34[2]  ,Interrupt Target 34 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT34[1]   ,Interrupt Target 34 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT34[0]   ,Interrupt Target 34 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT33[3]   ,Interrupt Target 33 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT33[2]   ,Interrupt Target 33 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT33[1]  ,Interrupt Target 33 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT33[0]  ,Interrupt Target 33 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT32[3]   ,Interrupt Target 32 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT32[2]   ,Interrupt Target 32 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT32[1]   ,Interrupt Target 32 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT32[0]   ,Interrupt Target 32 SPI CPU0" "0,1"
group.long 0x824++0x03
    line.long 0x00 "ICDIPTR9,Interrupt SPI Target Register 9"
        bitfld.long 0x00 27. " IT39[3]   ,Interrupt Target 39 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT39[2]   ,Interrupt Target 39 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT39[1]   ,Interrupt Target 39 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT39[0]   ,Interrupt Target 39 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT38[3]  ,Interrupt Target 38 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT38[2]  ,Interrupt Target 38 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT38[1]   ,Interrupt Target 38 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT38[0]   ,Interrupt Target 38 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT37[3]   ,Interrupt Target 37 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT37[2]   ,Interrupt Target 37 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT37[1]  ,Interrupt Target 37 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT37[0]  ,Interrupt Target 37 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT36[3]   ,Interrupt Target 36 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT36[2]   ,Interrupt Target 36 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT36[1]   ,Interrupt Target 36 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT36[0]   ,Interrupt Target 36 SPI CPU0" "0,1"
group.long 0x828++0x03
    line.long 0x00 "ICDIPTR10,Interrupt SPI Target Register 10"
        bitfld.long 0x00 27. " IT43[3]   ,Interrupt Target 43 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT43[2]   ,Interrupt Target 43 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT43[1]   ,Interrupt Target 43 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT43[0]   ,Interrupt Target 43 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT42[3]  ,Interrupt Target 42 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT42[2]  ,Interrupt Target 42 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT42[1]   ,Interrupt Target 42 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT42[0]   ,Interrupt Target 42 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT41[3]   ,Interrupt Target 41 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT41[2]   ,Interrupt Target 41 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT41[1]  ,Interrupt Target 41 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT41[0]  ,Interrupt Target 41 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT40[3]   ,Interrupt Target 40 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT40[2]   ,Interrupt Target 40 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT40[1]   ,Interrupt Target 40 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT40[0]   ,Interrupt Target 40 SPI CPU0" "0,1"
group.long 0x82C++0x03
    line.long 0x00 "ICDIPTR11,Interrupt SPI Target Register 11"
        bitfld.long 0x00 27. " IT47[3]   ,Interrupt Target 47 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT47[2]   ,Interrupt Target 47 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT47[1]   ,Interrupt Target 47 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT47[0]   ,Interrupt Target 47 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT46[3]  ,Interrupt Target 46 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT46[2]  ,Interrupt Target 46 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT46[1]   ,Interrupt Target 46 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT46[0]   ,Interrupt Target 46 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT45[3]   ,Interrupt Target 45 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT45[2]   ,Interrupt Target 45 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT45[1]  ,Interrupt Target 45 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT45[0]  ,Interrupt Target 45 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT44[3]   ,Interrupt Target 44 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT44[2]   ,Interrupt Target 44 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT44[1]   ,Interrupt Target 44 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT44[0]   ,Interrupt Target 44 SPI CPU0" "0,1"
group.long 0x830++0x03
    line.long 0x00 "ICDIPTR12,Interrupt SPI Target Register 12"
        bitfld.long 0x00 27. " IT51[3]   ,Interrupt Target 51 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT51[2]   ,Interrupt Target 51 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT51[1]   ,Interrupt Target 51 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT51[0]   ,Interrupt Target 51 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT50[3]  ,Interrupt Target 50 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT50[2]  ,Interrupt Target 50 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT50[1]   ,Interrupt Target 50 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT50[0]   ,Interrupt Target 50 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT49[3]   ,Interrupt Target 49 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT49[2]   ,Interrupt Target 49 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT49[1]  ,Interrupt Target 49 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT49[0]  ,Interrupt Target 49 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT48[3]   ,Interrupt Target 48 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT48[2]   ,Interrupt Target 48 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT48[1]   ,Interrupt Target 48 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT48[0]   ,Interrupt Target 48 SPI CPU0" "0,1"
group.long 0x834++0x03
    line.long 0x00 "ICDIPTR13,Interrupt SPI Target Register 13"
        bitfld.long 0x00 27. " IT55[3]   ,Interrupt Target 55 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT55[2]   ,Interrupt Target 55 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT55[1]   ,Interrupt Target 55 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT55[0]   ,Interrupt Target 55 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT54[3]  ,Interrupt Target 54 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT54[2]  ,Interrupt Target 54 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT54[1]   ,Interrupt Target 54 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT54[0]   ,Interrupt Target 54 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT53[3]   ,Interrupt Target 53 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT53[2]   ,Interrupt Target 53 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT53[1]  ,Interrupt Target 53 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT53[0]  ,Interrupt Target 53 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT52[3]   ,Interrupt Target 52 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT52[2]   ,Interrupt Target 52 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT52[1]   ,Interrupt Target 52 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT52[0]   ,Interrupt Target 52 SPI CPU0" "0,1"
group.long 0x838++0x03
    line.long 0x00 "ICDIPTR14,Interrupt SPI Target Register 14"
        bitfld.long 0x00 27. " IT59[3]   ,Interrupt Target 59 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT59[2]   ,Interrupt Target 59 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT59[1]   ,Interrupt Target 59 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT59[0]   ,Interrupt Target 59 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT58[3]  ,Interrupt Target 58 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT58[2]  ,Interrupt Target 58 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT58[1]   ,Interrupt Target 58 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT58[0]   ,Interrupt Target 58 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT57[3]   ,Interrupt Target 57 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT57[2]   ,Interrupt Target 57 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT57[1]  ,Interrupt Target 57 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT57[0]  ,Interrupt Target 57 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT56[3]   ,Interrupt Target 56 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT56[2]   ,Interrupt Target 56 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT56[1]   ,Interrupt Target 56 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT56[0]   ,Interrupt Target 56 SPI CPU0" "0,1"
group.long 0x83C++0x03
    line.long 0x00 "ICDIPTR15,Interrupt SPI Target Register 15"
        bitfld.long 0x00 27. " IT63[3]   ,Interrupt Target 63 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT63[2]   ,Interrupt Target 63 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT63[1]   ,Interrupt Target 63 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT63[0]   ,Interrupt Target 63 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT62[3]  ,Interrupt Target 62 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT62[2]  ,Interrupt Target 62 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT62[1]   ,Interrupt Target 62 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT62[0]   ,Interrupt Target 62 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT61[3]   ,Interrupt Target 61 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT61[2]   ,Interrupt Target 61 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT61[1]  ,Interrupt Target 61 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT61[0]  ,Interrupt Target 61 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT60[3]   ,Interrupt Target 60 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT60[2]   ,Interrupt Target 60 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT60[1]   ,Interrupt Target 60 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT60[0]   ,Interrupt Target 60 SPI CPU0" "0,1"
group.long 0x840++0x03
    line.long 0x00 "ICDIPTR16,Interrupt SPI Target Register 16"
        bitfld.long 0x00 27. " IT67[3]   ,Interrupt Target 67 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT67[2]   ,Interrupt Target 67 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT67[1]   ,Interrupt Target 67 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT67[0]   ,Interrupt Target 67 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT66[3]  ,Interrupt Target 66 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT66[2]  ,Interrupt Target 66 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT66[1]   ,Interrupt Target 66 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT66[0]   ,Interrupt Target 66 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT65[3]   ,Interrupt Target 65 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT65[2]   ,Interrupt Target 65 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT65[1]  ,Interrupt Target 65 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT65[0]  ,Interrupt Target 65 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT64[3]   ,Interrupt Target 64 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT64[2]   ,Interrupt Target 64 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT64[1]   ,Interrupt Target 64 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT64[0]   ,Interrupt Target 64 SPI CPU0" "0,1"
group.long 0x844++0x03
    line.long 0x00 "ICDIPTR17,Interrupt SPI Target Register 17"
        bitfld.long 0x00 27. " IT71[3]   ,Interrupt Target 71 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT71[2]   ,Interrupt Target 71 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT71[1]   ,Interrupt Target 71 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT71[0]   ,Interrupt Target 71 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT70[3]  ,Interrupt Target 70 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT70[2]  ,Interrupt Target 70 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT70[1]   ,Interrupt Target 70 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT70[0]   ,Interrupt Target 70 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT69[3]   ,Interrupt Target 69 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT69[2]   ,Interrupt Target 69 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT69[1]  ,Interrupt Target 69 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT69[0]  ,Interrupt Target 69 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT68[3]   ,Interrupt Target 68 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT68[2]   ,Interrupt Target 68 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT68[1]   ,Interrupt Target 68 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT68[0]   ,Interrupt Target 68 SPI CPU0" "0,1"
group.long 0x848++0x03
    line.long 0x00 "ICDIPTR18,Interrupt SPI Target Register 18"
        bitfld.long 0x00 27. " IT75[3]   ,Interrupt Target 75 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT75[2]   ,Interrupt Target 75 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT75[1]   ,Interrupt Target 75 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT75[0]   ,Interrupt Target 75 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT74[3]  ,Interrupt Target 74 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT74[2]  ,Interrupt Target 74 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT74[1]   ,Interrupt Target 74 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT74[0]   ,Interrupt Target 74 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT73[3]   ,Interrupt Target 73 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT73[2]   ,Interrupt Target 73 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT73[1]  ,Interrupt Target 73 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT73[0]  ,Interrupt Target 73 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT72[3]   ,Interrupt Target 72 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT72[2]   ,Interrupt Target 72 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT72[1]   ,Interrupt Target 72 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT72[0]   ,Interrupt Target 72 SPI CPU0" "0,1"
group.long 0x84C++0x03
    line.long 0x00 "ICDIPTR19,Interrupt SPI Target Register 19"
        bitfld.long 0x00 27. " IT79[3]   ,Interrupt Target 79 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT79[2]   ,Interrupt Target 79 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT79[1]   ,Interrupt Target 79 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT79[0]   ,Interrupt Target 79 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT78[3]  ,Interrupt Target 78 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT78[2]  ,Interrupt Target 78 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT78[1]   ,Interrupt Target 78 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT78[0]   ,Interrupt Target 78 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT77[3]   ,Interrupt Target 77 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT77[2]   ,Interrupt Target 77 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT77[1]  ,Interrupt Target 77 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT77[0]  ,Interrupt Target 77 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT76[3]   ,Interrupt Target 76 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT76[2]   ,Interrupt Target 76 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT76[1]   ,Interrupt Target 76 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT76[0]   ,Interrupt Target 76 SPI CPU0" "0,1"
group.long 0x850++0x03
    line.long 0x00 "ICDIPTR20,Interrupt SPI Target Register 20"
        bitfld.long 0x00 27. " IT83[3]   ,Interrupt Target 83 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT83[2]   ,Interrupt Target 83 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT83[1]   ,Interrupt Target 83 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT83[0]   ,Interrupt Target 83 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT82[3]  ,Interrupt Target 82 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT82[2]  ,Interrupt Target 82 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT82[1]   ,Interrupt Target 82 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT82[0]   ,Interrupt Target 82 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT81[3]   ,Interrupt Target 81 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT81[2]   ,Interrupt Target 81 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT81[1]  ,Interrupt Target 81 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT81[0]  ,Interrupt Target 81 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT80[3]   ,Interrupt Target 80 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT80[2]   ,Interrupt Target 80 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT80[1]   ,Interrupt Target 80 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT80[0]   ,Interrupt Target 80 SPI CPU0" "0,1"
group.long 0x854++0x03
    line.long 0x00 "ICDIPTR21,Interrupt SPI Target Register 21"
        bitfld.long 0x00 27. " IT87[3]   ,Interrupt Target 87 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT87[2]   ,Interrupt Target 87 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT87[1]   ,Interrupt Target 87 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT87[0]   ,Interrupt Target 87 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT86[3]  ,Interrupt Target 86 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT86[2]  ,Interrupt Target 86 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT86[1]   ,Interrupt Target 86 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT86[0]   ,Interrupt Target 86 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT85[3]   ,Interrupt Target 85 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT85[2]   ,Interrupt Target 85 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT85[1]  ,Interrupt Target 85 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT85[0]  ,Interrupt Target 85 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT84[3]   ,Interrupt Target 84 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT84[2]   ,Interrupt Target 84 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT84[1]   ,Interrupt Target 84 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT84[0]   ,Interrupt Target 84 SPI CPU0" "0,1"
group.long 0x858++0x03
    line.long 0x00 "ICDIPTR22,Interrupt SPI Target Register 22"
        bitfld.long 0x00 27. " IT91[3]   ,Interrupt Target 91 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT91[2]   ,Interrupt Target 91 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT91[1]   ,Interrupt Target 91 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT91[0]   ,Interrupt Target 91 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT90[3]  ,Interrupt Target 90 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT90[2]  ,Interrupt Target 90 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT90[1]   ,Interrupt Target 90 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT90[0]   ,Interrupt Target 90 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT89[3]   ,Interrupt Target 89 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT89[2]   ,Interrupt Target 89 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT89[1]  ,Interrupt Target 89 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT89[0]  ,Interrupt Target 89 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT88[3]   ,Interrupt Target 88 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT88[2]   ,Interrupt Target 88 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT88[1]   ,Interrupt Target 88 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT88[0]   ,Interrupt Target 88 SPI CPU0" "0,1"
group.long 0x85C++0x03
    line.long 0x00 "ICDIPTR23,Interrupt SPI Target Register 23"
        bitfld.long 0x00 27. " IT95[3]   ,Interrupt Target 95 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT95[2]   ,Interrupt Target 95 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT95[1]   ,Interrupt Target 95 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT95[0]   ,Interrupt Target 95 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT94[3]  ,Interrupt Target 94 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT94[2]  ,Interrupt Target 94 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT94[1]   ,Interrupt Target 94 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT94[0]   ,Interrupt Target 94 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT93[3]   ,Interrupt Target 93 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT93[2]   ,Interrupt Target 93 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT93[1]  ,Interrupt Target 93 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT93[0]  ,Interrupt Target 93 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT92[3]   ,Interrupt Target 92 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT92[2]   ,Interrupt Target 92 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT92[1]   ,Interrupt Target 92 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT92[0]   ,Interrupt Target 92 SPI CPU0" "0,1"
group.long 0x860++0x03
    line.long 0x00 "ICDIPTR24,Interrupt SPI Target Register 24"
        bitfld.long 0x00 27. " IT99[3]   ,Interrupt Target 99 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT99[2]   ,Interrupt Target 99 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT99[1]   ,Interrupt Target 99 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT99[0]   ,Interrupt Target 99 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT98[3]  ,Interrupt Target 98 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT98[2]  ,Interrupt Target 98 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT98[1]   ,Interrupt Target 98 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT98[0]   ,Interrupt Target 98 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT97[3]   ,Interrupt Target 97 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT97[2]   ,Interrupt Target 97 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT97[1]  ,Interrupt Target 97 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT97[0]  ,Interrupt Target 97 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT96[3]   ,Interrupt Target 96 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT96[2]   ,Interrupt Target 96 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT96[1]   ,Interrupt Target 96 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT96[0]   ,Interrupt Target 96 SPI CPU0" "0,1"
group.long 0x864++0x03
    line.long 0x00 "ICDIPTR25,Interrupt SPI Target Register 25"
        bitfld.long 0x00 27. " IT103[3]  ,Interrupt Target 103 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT103[2]  ,Interrupt Target 103 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT103[1]  ,Interrupt Target 103 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT103[0]  ,Interrupt Target 103 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT102[3] ,Interrupt Target 102 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT102[2] ,Interrupt Target 102 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT102[1]  ,Interrupt Target 102 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT102[0]  ,Interrupt Target 102 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT101[3]  ,Interrupt Target 101 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT101[2]  ,Interrupt Target 101 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT101[1] ,Interrupt Target 101 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT101[0] ,Interrupt Target 101 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT100[3]  ,Interrupt Target 100 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT100[2]  ,Interrupt Target 100 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT100[1]  ,Interrupt Target 100 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT100[0]  ,Interrupt Target 100 SPI CPU0" "0,1"
group.long 0x868++0x03
    line.long 0x00 "ICDIPTR26,Interrupt SPI Target Register 26"
        bitfld.long 0x00 27. " IT107[3]  ,Interrupt Target 107 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT107[2]  ,Interrupt Target 107 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT107[1]  ,Interrupt Target 107 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT107[0]  ,Interrupt Target 107 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT106[3] ,Interrupt Target 106 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT106[2] ,Interrupt Target 106 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT106[1]  ,Interrupt Target 106 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT106[0]  ,Interrupt Target 106 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT105[3]  ,Interrupt Target 105 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT105[2]  ,Interrupt Target 105 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT105[1] ,Interrupt Target 105 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT105[0] ,Interrupt Target 105 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT104[3]  ,Interrupt Target 104 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT104[2]  ,Interrupt Target 104 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT104[1]  ,Interrupt Target 104 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT104[0]  ,Interrupt Target 104 SPI CPU0" "0,1"
group.long 0x86C++0x03
    line.long 0x00 "ICDIPTR27,Interrupt SPI Target Register 27"
        bitfld.long 0x00 27. " IT111[3]  ,Interrupt Target 111 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT111[2]  ,Interrupt Target 111 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT111[1]  ,Interrupt Target 111 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT111[0]  ,Interrupt Target 111 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT110[3] ,Interrupt Target 110 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT110[2] ,Interrupt Target 110 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT110[1]  ,Interrupt Target 110 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT110[0]  ,Interrupt Target 110 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT109[3]  ,Interrupt Target 109 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT109[2]  ,Interrupt Target 109 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT109[1] ,Interrupt Target 109 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT109[0] ,Interrupt Target 109 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT108[3]  ,Interrupt Target 108 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT108[2]  ,Interrupt Target 108 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT108[1]  ,Interrupt Target 108 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT108[0]  ,Interrupt Target 108 SPI CPU0" "0,1"
group.long 0x870++0x03
    line.long 0x00 "ICDIPTR28,Interrupt SPI Target Register 28"
        bitfld.long 0x00 27. " IT115[3]  ,Interrupt Target 115 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT115[2]  ,Interrupt Target 115 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT115[1]  ,Interrupt Target 115 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT115[0]  ,Interrupt Target 115 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT114[3] ,Interrupt Target 114 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT114[2] ,Interrupt Target 114 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT114[1]  ,Interrupt Target 114 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT114[0]  ,Interrupt Target 114 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT113[3]  ,Interrupt Target 113 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT113[2]  ,Interrupt Target 113 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT113[1] ,Interrupt Target 113 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT113[0] ,Interrupt Target 113 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT112[3]  ,Interrupt Target 112 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT112[2]  ,Interrupt Target 112 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT112[1]  ,Interrupt Target 112 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT112[0]  ,Interrupt Target 112 SPI CPU0" "0,1"
group.long 0x874++0x03
    line.long 0x00 "ICDIPTR29,Interrupt SPI Target Register 29"
        bitfld.long 0x00 27. " IT119[3]  ,Interrupt Target 119 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT119[2]  ,Interrupt Target 119 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT119[1]  ,Interrupt Target 119 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT119[0]  ,Interrupt Target 119 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT118[3] ,Interrupt Target 118 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT118[2] ,Interrupt Target 118 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT118[1]  ,Interrupt Target 118 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT118[0]  ,Interrupt Target 118 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT117[3]  ,Interrupt Target 117 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT117[2]  ,Interrupt Target 117 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT117[1] ,Interrupt Target 117 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT117[0] ,Interrupt Target 117 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT116[3]  ,Interrupt Target 116 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT116[2]  ,Interrupt Target 116 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT116[1]  ,Interrupt Target 116 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT116[0]  ,Interrupt Target 116 SPI CPU0" "0,1"
group.long 0x878++0x03
    line.long 0x00 "ICDIPTR30,Interrupt SPI Target Register 30"
        bitfld.long 0x00 27. " IT123[3]  ,Interrupt Target 123 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT123[2]  ,Interrupt Target 123 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT123[1]  ,Interrupt Target 123 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT123[0]  ,Interrupt Target 123 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT122[3] ,Interrupt Target 122 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT122[2] ,Interrupt Target 122 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT122[1]  ,Interrupt Target 122 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT122[0]  ,Interrupt Target 122 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT121[3]  ,Interrupt Target 121 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT121[2]  ,Interrupt Target 121 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT121[1] ,Interrupt Target 121 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT121[0] ,Interrupt Target 121 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT120[3]  ,Interrupt Target 120 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT120[2]  ,Interrupt Target 120 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT120[1]  ,Interrupt Target 120 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT120[0]  ,Interrupt Target 120 SPI CPU0" "0,1"
group.long 0x87C++0x03
    line.long 0x00 "ICDIPTR31,Interrupt SPI Target Register 31"
        bitfld.long 0x00 27. " IT127[3]  ,Interrupt Target 127 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT127[2]  ,Interrupt Target 127 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT127[1]  ,Interrupt Target 127 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT127[0]  ,Interrupt Target 127 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT126[3] ,Interrupt Target 126 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT126[2] ,Interrupt Target 126 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT126[1]  ,Interrupt Target 126 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT126[0]  ,Interrupt Target 126 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT125[3]  ,Interrupt Target 125 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT125[2]  ,Interrupt Target 125 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT125[1] ,Interrupt Target 125 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT125[0] ,Interrupt Target 125 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT124[3]  ,Interrupt Target 124 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT124[2]  ,Interrupt Target 124 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT124[1]  ,Interrupt Target 124 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT124[0]  ,Interrupt Target 124 SPI CPU0" "0,1"
group.long 0x880++0x03
    line.long 0x00 "ICDIPTR32,Interrupt SPI Target Register 32"
        bitfld.long 0x00 27. " IT131[3]  ,Interrupt Target 131 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT131[2]  ,Interrupt Target 131 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT131[1]  ,Interrupt Target 131 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT131[0]  ,Interrupt Target 131 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT130[3] ,Interrupt Target 130 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT130[2] ,Interrupt Target 130 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT130[1]  ,Interrupt Target 130 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT130[0]  ,Interrupt Target 130 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT129[3]  ,Interrupt Target 129 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT129[2]  ,Interrupt Target 129 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT129[1] ,Interrupt Target 129 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT129[0] ,Interrupt Target 129 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT128[3]  ,Interrupt Target 128 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT128[2]  ,Interrupt Target 128 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT128[1]  ,Interrupt Target 128 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT128[0]  ,Interrupt Target 128 SPI CPU0" "0,1"
group.long 0x884++0x03
    line.long 0x00 "ICDIPTR33,Interrupt SPI Target Register 33"
        bitfld.long 0x00 27. " IT135[3]  ,Interrupt Target 135 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT135[2]  ,Interrupt Target 135 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT135[1]  ,Interrupt Target 135 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT135[0]  ,Interrupt Target 135 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT134[3] ,Interrupt Target 134 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT134[2] ,Interrupt Target 134 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT134[1]  ,Interrupt Target 134 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT134[0]  ,Interrupt Target 134 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT133[3]  ,Interrupt Target 133 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT133[2]  ,Interrupt Target 133 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT133[1] ,Interrupt Target 133 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT133[0] ,Interrupt Target 133 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT132[3]  ,Interrupt Target 132 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT132[2]  ,Interrupt Target 132 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT132[1]  ,Interrupt Target 132 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT132[0]  ,Interrupt Target 132 SPI CPU0" "0,1"
group.long 0x888++0x03
    line.long 0x00 "ICDIPTR34,Interrupt SPI Target Register 34"
        bitfld.long 0x00 27. " IT139[3]  ,Interrupt Target 139 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT139[2]  ,Interrupt Target 139 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT139[1]  ,Interrupt Target 139 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT139[0]  ,Interrupt Target 139 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT138[3] ,Interrupt Target 138 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT138[2] ,Interrupt Target 138 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT138[1]  ,Interrupt Target 138 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT138[0]  ,Interrupt Target 138 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT137[3]  ,Interrupt Target 137 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT137[2]  ,Interrupt Target 137 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT137[1] ,Interrupt Target 137 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT137[0] ,Interrupt Target 137 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT136[3]  ,Interrupt Target 136 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT136[2]  ,Interrupt Target 136 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT136[1]  ,Interrupt Target 136 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT136[0]  ,Interrupt Target 136 SPI CPU0" "0,1"
group.long 0x88C++0x03
    line.long 0x00 "ICDIPTR35,Interrupt SPI Target Register 35"
        bitfld.long 0x00 27. " IT143[3]  ,Interrupt Target 143 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT143[2]  ,Interrupt Target 143 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT143[1]  ,Interrupt Target 143 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT143[0]  ,Interrupt Target 143 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT142[3] ,Interrupt Target 142 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT142[2] ,Interrupt Target 142 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT142[1]  ,Interrupt Target 142 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT142[0]  ,Interrupt Target 142 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT141[3]  ,Interrupt Target 141 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT141[2]  ,Interrupt Target 141 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT141[1] ,Interrupt Target 141 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT141[0] ,Interrupt Target 141 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT140[3]  ,Interrupt Target 140 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT140[2]  ,Interrupt Target 140 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT140[1]  ,Interrupt Target 140 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT140[0]  ,Interrupt Target 140 SPI CPU0" "0,1"
group.long 0x890++0x03
    line.long 0x00 "ICDIPTR36,Interrupt SPI Target Register 36"
        bitfld.long 0x00 27. " IT147[3]  ,Interrupt Target 147 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT147[2]  ,Interrupt Target 147 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT147[1]  ,Interrupt Target 147 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT147[0]  ,Interrupt Target 147 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT146[3] ,Interrupt Target 146 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT146[2] ,Interrupt Target 146 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT146[1]  ,Interrupt Target 146 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT146[0]  ,Interrupt Target 146 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT145[3]  ,Interrupt Target 145 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT145[2]  ,Interrupt Target 145 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT145[1] ,Interrupt Target 145 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT145[0] ,Interrupt Target 145 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT144[3]  ,Interrupt Target 144 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT144[2]  ,Interrupt Target 144 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT144[1]  ,Interrupt Target 144 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT144[0]  ,Interrupt Target 144 SPI CPU0" "0,1"
group.long 0x894++0x03
    line.long 0x00 "ICDIPTR37,Interrupt SPI Target Register 37"
        bitfld.long 0x00 27. " IT151[3]  ,Interrupt Target 151 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT151[2]  ,Interrupt Target 151 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT151[1]  ,Interrupt Target 151 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT151[0]  ,Interrupt Target 151 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT150[3] ,Interrupt Target 150 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT150[2] ,Interrupt Target 150 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT150[1]  ,Interrupt Target 150 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT150[0]  ,Interrupt Target 150 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT149[3]  ,Interrupt Target 149 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT149[2]  ,Interrupt Target 149 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT149[1] ,Interrupt Target 149 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT149[0] ,Interrupt Target 149 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT148[3]  ,Interrupt Target 148 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT148[2]  ,Interrupt Target 148 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT148[1]  ,Interrupt Target 148 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT148[0]  ,Interrupt Target 148 SPI CPU0" "0,1"
group.long 0x898++0x03
    line.long 0x00 "ICDIPTR38,Interrupt SPI Target Register 38"
        bitfld.long 0x00 27. " IT155[3]  ,Interrupt Target 155 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT155[2]  ,Interrupt Target 155 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT155[1]  ,Interrupt Target 155 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT155[0]  ,Interrupt Target 155 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT154[3] ,Interrupt Target 154 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT154[2] ,Interrupt Target 154 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT154[1]  ,Interrupt Target 154 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT154[0]  ,Interrupt Target 154 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT153[3]  ,Interrupt Target 153 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT153[2]  ,Interrupt Target 153 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT153[1] ,Interrupt Target 153 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT153[0] ,Interrupt Target 153 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT152[3]  ,Interrupt Target 152 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT152[2]  ,Interrupt Target 152 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT152[1]  ,Interrupt Target 152 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT152[0]  ,Interrupt Target 152 SPI CPU0" "0,1"
group.long 0x89C++0x03
    line.long 0x00 "ICDIPTR39,Interrupt SPI Target Register 39"
        bitfld.long 0x00 27. " IT159[3]  ,Interrupt Target 159 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT159[2]  ,Interrupt Target 159 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT159[1]  ,Interrupt Target 159 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT159[0]  ,Interrupt Target 159 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT158[3] ,Interrupt Target 158 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT158[2] ,Interrupt Target 158 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT158[1]  ,Interrupt Target 158 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT158[0]  ,Interrupt Target 158 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT157[3]  ,Interrupt Target 157 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT157[2]  ,Interrupt Target 157 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT157[1] ,Interrupt Target 157 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT157[0] ,Interrupt Target 157 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT156[3]  ,Interrupt Target 156 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT156[2]  ,Interrupt Target 156 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT156[1]  ,Interrupt Target 156 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT156[0]  ,Interrupt Target 156 SPI CPU0" "0,1"
group.long 0x8A0++0x03
    line.long 0x00 "ICDIPTR40,Interrupt SPI Target Register 40"
        bitfld.long 0x00 27. " IT163[3]  ,Interrupt Target 163 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT163[2]  ,Interrupt Target 163 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT163[1]  ,Interrupt Target 163 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT163[0]  ,Interrupt Target 163 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT162[3] ,Interrupt Target 162 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT162[2] ,Interrupt Target 162 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT162[1]  ,Interrupt Target 162 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT162[0]  ,Interrupt Target 162 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT161[3]  ,Interrupt Target 161 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT161[2]  ,Interrupt Target 161 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT161[1] ,Interrupt Target 161 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT161[0] ,Interrupt Target 161 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT160[3]  ,Interrupt Target 160 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT160[2]  ,Interrupt Target 160 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT160[1]  ,Interrupt Target 160 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT160[0]  ,Interrupt Target 160 SPI CPU0" "0,1"
group.long 0x8A4++0x03
    line.long 0x00 "ICDIPTR41,Interrupt SPI Target Register 41"
        bitfld.long 0x00 27. " IT167[3]  ,Interrupt Target 167 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT167[2]  ,Interrupt Target 167 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT167[1]  ,Interrupt Target 167 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT167[0]  ,Interrupt Target 167 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT166[3] ,Interrupt Target 166 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT166[2] ,Interrupt Target 166 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT166[1]  ,Interrupt Target 166 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT166[0]  ,Interrupt Target 166 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT165[3]  ,Interrupt Target 165 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT165[2]  ,Interrupt Target 165 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT165[1] ,Interrupt Target 165 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT165[0] ,Interrupt Target 165 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT164[3]  ,Interrupt Target 164 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT164[2]  ,Interrupt Target 164 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT164[1]  ,Interrupt Target 164 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT164[0]  ,Interrupt Target 164 SPI CPU0" "0,1"
group.long 0x8A8++0x03
    line.long 0x00 "ICDIPTR42,Interrupt SPI Target Register 42"
        bitfld.long 0x00 27. " IT171[3]  ,Interrupt Target 171 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT171[2]  ,Interrupt Target 171 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT171[1]  ,Interrupt Target 171 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT171[0]  ,Interrupt Target 171 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT170[3] ,Interrupt Target 170 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT170[2] ,Interrupt Target 170 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT170[1]  ,Interrupt Target 170 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT170[0]  ,Interrupt Target 170 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT169[3]  ,Interrupt Target 169 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT169[2]  ,Interrupt Target 169 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT169[1] ,Interrupt Target 169 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT169[0] ,Interrupt Target 169 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT168[3]  ,Interrupt Target 168 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT168[2]  ,Interrupt Target 168 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT168[1]  ,Interrupt Target 168 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT168[0]  ,Interrupt Target 168 SPI CPU0" "0,1"
group.long 0x8AC++0x03
    line.long 0x00 "ICDIPTR43,Interrupt SPI Target Register 43"
        bitfld.long 0x00 27. " IT175[3]  ,Interrupt Target 175 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT175[2]  ,Interrupt Target 175 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT175[1]  ,Interrupt Target 175 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT175[0]  ,Interrupt Target 175 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT174[3] ,Interrupt Target 174 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT174[2] ,Interrupt Target 174 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT174[1]  ,Interrupt Target 174 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT174[0]  ,Interrupt Target 174 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT173[3]  ,Interrupt Target 173 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT173[2]  ,Interrupt Target 173 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT173[1] ,Interrupt Target 173 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT173[0] ,Interrupt Target 173 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT172[3]  ,Interrupt Target 172 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT172[2]  ,Interrupt Target 172 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT172[1]  ,Interrupt Target 172 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT172[0]  ,Interrupt Target 172 SPI CPU0" "0,1"
group.long 0x8B0++0x03
    line.long 0x00 "ICDIPTR44,Interrupt SPI Target Register 44"
        bitfld.long 0x00 27. " IT179[3]  ,Interrupt Target 179 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT179[2]  ,Interrupt Target 179 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT179[1]  ,Interrupt Target 179 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT179[0]  ,Interrupt Target 179 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT178[3] ,Interrupt Target 178 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT178[2] ,Interrupt Target 178 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT178[1]  ,Interrupt Target 178 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT178[0]  ,Interrupt Target 178 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT177[3]  ,Interrupt Target 177 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT177[2]  ,Interrupt Target 177 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT177[1] ,Interrupt Target 177 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT177[0] ,Interrupt Target 177 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT176[3]  ,Interrupt Target 176 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT176[2]  ,Interrupt Target 176 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT176[1]  ,Interrupt Target 176 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT176[0]  ,Interrupt Target 176 SPI CPU0" "0,1"
group.long 0x8B4++0x03
    line.long 0x00 "ICDIPTR45,Interrupt SPI Target Register 45"
        bitfld.long 0x00 27. " IT183[3]  ,Interrupt Target 183 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT183[2]  ,Interrupt Target 183 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT183[1]  ,Interrupt Target 183 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT183[0]  ,Interrupt Target 183 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT182[3] ,Interrupt Target 182 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT182[2] ,Interrupt Target 182 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT182[1]  ,Interrupt Target 182 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT182[0]  ,Interrupt Target 182 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT181[3]  ,Interrupt Target 181 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT181[2]  ,Interrupt Target 181 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT181[1] ,Interrupt Target 181 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT181[0] ,Interrupt Target 181 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT180[3]  ,Interrupt Target 180 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT180[2]  ,Interrupt Target 180 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT180[1]  ,Interrupt Target 180 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT180[0]  ,Interrupt Target 180 SPI CPU0" "0,1"
group.long 0x8B8++0x03
    line.long 0x00 "ICDIPTR46,Interrupt SPI Target Register 46"
        bitfld.long 0x00 27. " IT187[3]  ,Interrupt Target 187 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT187[2]  ,Interrupt Target 187 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT187[1]  ,Interrupt Target 187 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT187[0]  ,Interrupt Target 187 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT186[3] ,Interrupt Target 186 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT186[2] ,Interrupt Target 186 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT186[1]  ,Interrupt Target 186 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT186[0]  ,Interrupt Target 186 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT185[3]  ,Interrupt Target 185 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT185[2]  ,Interrupt Target 185 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT185[1] ,Interrupt Target 185 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT185[0] ,Interrupt Target 185 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT184[3]  ,Interrupt Target 184 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT184[2]  ,Interrupt Target 184 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT184[1]  ,Interrupt Target 184 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT184[0]  ,Interrupt Target 184 SPI CPU0" "0,1"
group.long 0x8BC++0x03
    line.long 0x00 "ICDIPTR47,Interrupt SPI Target Register 47"
        bitfld.long 0x00 27. " IT191[3]  ,Interrupt Target 191 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT191[2]  ,Interrupt Target 191 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT191[1]  ,Interrupt Target 191 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT191[0]  ,Interrupt Target 191 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT190[3] ,Interrupt Target 190 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT190[2] ,Interrupt Target 190 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT190[1]  ,Interrupt Target 190 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT190[0]  ,Interrupt Target 190 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT189[3]  ,Interrupt Target 189 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT189[2]  ,Interrupt Target 189 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT189[1] ,Interrupt Target 189 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT189[0] ,Interrupt Target 189 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT188[3]  ,Interrupt Target 188 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT188[2]  ,Interrupt Target 188 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT188[1]  ,Interrupt Target 188 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT188[0]  ,Interrupt Target 188 SPI CPU0" "0,1"
group.long 0x8C0++0x03
    line.long 0x00 "ICDIPTR48,Interrupt SPI Target Register 48"
        bitfld.long 0x00 27. " IT195[3]  ,Interrupt Target 195 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT195[2]  ,Interrupt Target 195 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT195[1]  ,Interrupt Target 195 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT195[0]  ,Interrupt Target 195 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT194[3] ,Interrupt Target 194 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT194[2] ,Interrupt Target 194 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT194[1]  ,Interrupt Target 194 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT194[0]  ,Interrupt Target 194 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT193[3]  ,Interrupt Target 193 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT193[2]  ,Interrupt Target 193 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT193[1] ,Interrupt Target 193 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT193[0] ,Interrupt Target 193 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT192[3]  ,Interrupt Target 192 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT192[2]  ,Interrupt Target 192 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT192[1]  ,Interrupt Target 192 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT192[0]  ,Interrupt Target 192 SPI CPU0" "0,1"
group.long 0x8C4++0x03
    line.long 0x00 "ICDIPTR49,Interrupt SPI Target Register 49"
        bitfld.long 0x00 27. " IT199[3]  ,Interrupt Target 199 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT199[2]  ,Interrupt Target 199 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT199[1]  ,Interrupt Target 199 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT199[0]  ,Interrupt Target 199 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT198[3] ,Interrupt Target 198 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT198[2] ,Interrupt Target 198 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT198[1]  ,Interrupt Target 198 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT198[0]  ,Interrupt Target 198 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT197[3]  ,Interrupt Target 197 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT197[2]  ,Interrupt Target 197 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT197[1] ,Interrupt Target 197 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT197[0] ,Interrupt Target 197 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT196[3]  ,Interrupt Target 196 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT196[2]  ,Interrupt Target 196 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT196[1]  ,Interrupt Target 196 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT196[0]  ,Interrupt Target 196 SPI CPU0" "0,1"
group.long 0x8C8++0x03
    line.long 0x00 "ICDIPTR50,Interrupt SPI Target Register 50"
        bitfld.long 0x00 27. " IT203[3]  ,Interrupt Target 203 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT203[2]  ,Interrupt Target 203 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT203[1]  ,Interrupt Target 203 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT203[0]  ,Interrupt Target 203 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT202[3] ,Interrupt Target 202 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT202[2] ,Interrupt Target 202 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT202[1]  ,Interrupt Target 202 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT202[0]  ,Interrupt Target 202 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT201[3]  ,Interrupt Target 201 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT201[2]  ,Interrupt Target 201 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT201[1] ,Interrupt Target 201 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT201[0] ,Interrupt Target 201 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT200[3]  ,Interrupt Target 200 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT200[2]  ,Interrupt Target 200 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT200[1]  ,Interrupt Target 200 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT200[0]  ,Interrupt Target 200 SPI CPU0" "0,1"
group.long 0x8CC++0x03
    line.long 0x00 "ICDIPTR51,Interrupt SPI Target Register 51"
        bitfld.long 0x00 27. " IT207[3]  ,Interrupt Target 207 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT207[2]  ,Interrupt Target 207 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT207[1]  ,Interrupt Target 207 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT207[0]  ,Interrupt Target 207 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT206[3] ,Interrupt Target 206 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT206[2] ,Interrupt Target 206 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT206[1]  ,Interrupt Target 206 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT206[0]  ,Interrupt Target 206 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT205[3]  ,Interrupt Target 205 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT205[2]  ,Interrupt Target 205 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT205[1] ,Interrupt Target 205 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT205[0] ,Interrupt Target 205 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT204[3]  ,Interrupt Target 204 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT204[2]  ,Interrupt Target 204 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT204[1]  ,Interrupt Target 204 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT204[0]  ,Interrupt Target 204 SPI CPU0" "0,1"
group.long 0x8D0++0x03
    line.long 0x00 "ICDIPTR52,Interrupt SPI Target Register 52"
        bitfld.long 0x00 27. " IT211[3]  ,Interrupt Target 211 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT211[2]  ,Interrupt Target 211 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT211[1]  ,Interrupt Target 211 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT211[0]  ,Interrupt Target 211 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT210[3] ,Interrupt Target 210 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT210[2] ,Interrupt Target 210 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT210[1]  ,Interrupt Target 210 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT210[0]  ,Interrupt Target 210 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT209[3]  ,Interrupt Target 209 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT209[2]  ,Interrupt Target 209 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT209[1] ,Interrupt Target 209 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT209[0] ,Interrupt Target 209 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT208[3]  ,Interrupt Target 208 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT208[2]  ,Interrupt Target 208 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT208[1]  ,Interrupt Target 208 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT208[0]  ,Interrupt Target 208 SPI CPU0" "0,1"
group.long 0x8D4++0x03
    line.long 0x00 "ICDIPTR53,Interrupt SPI Target Register 53"
        bitfld.long 0x00 27. " IT215[3]  ,Interrupt Target 215 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT215[2]  ,Interrupt Target 215 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT215[1]  ,Interrupt Target 215 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT215[0]  ,Interrupt Target 215 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT214[3] ,Interrupt Target 214 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT214[2] ,Interrupt Target 214 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT214[1]  ,Interrupt Target 214 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT214[0]  ,Interrupt Target 214 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT213[3]  ,Interrupt Target 213 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT213[2]  ,Interrupt Target 213 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT213[1] ,Interrupt Target 213 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT213[0] ,Interrupt Target 213 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT212[3]  ,Interrupt Target 212 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT212[2]  ,Interrupt Target 212 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT212[1]  ,Interrupt Target 212 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT212[0]  ,Interrupt Target 212 SPI CPU0" "0,1"
group.long 0x8D8++0x03
    line.long 0x00 "ICDIPTR54,Interrupt SPI Target Register 54"
        bitfld.long 0x00 27. " IT219[3]  ,Interrupt Target 219 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT219[2]  ,Interrupt Target 219 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT219[1]  ,Interrupt Target 219 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT219[0]  ,Interrupt Target 219 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT218[3] ,Interrupt Target 218 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT218[2] ,Interrupt Target 218 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT218[1]  ,Interrupt Target 218 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT218[0]  ,Interrupt Target 218 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT217[3]  ,Interrupt Target 217 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT217[2]  ,Interrupt Target 217 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT217[1] ,Interrupt Target 217 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT217[0] ,Interrupt Target 217 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT216[3]  ,Interrupt Target 216 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT216[2]  ,Interrupt Target 216 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT216[1]  ,Interrupt Target 216 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT216[0]  ,Interrupt Target 216 SPI CPU0" "0,1"
group.long 0x8DC++0x03
    line.long 0x00 "ICDIPTR55,Interrupt SPI Target Register 55"
        bitfld.long 0x00 27. " IT223[3]  ,Interrupt Target 223 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT223[2]  ,Interrupt Target 223 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT223[1]  ,Interrupt Target 223 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT223[0]  ,Interrupt Target 223 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT222[3] ,Interrupt Target 222 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT222[2] ,Interrupt Target 222 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT222[1]  ,Interrupt Target 222 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT222[0]  ,Interrupt Target 222 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT221[3]  ,Interrupt Target 221 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT221[2]  ,Interrupt Target 221 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT221[1] ,Interrupt Target 221 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT221[0] ,Interrupt Target 221 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT220[3]  ,Interrupt Target 220 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT220[2]  ,Interrupt Target 220 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT220[1]  ,Interrupt Target 220 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT220[0]  ,Interrupt Target 220 SPI CPU0" "0,1"
group.long 0x8E0++0x03
    line.long 0x00 "ICDIPTR56,Interrupt SPI Target Register 56"
        bitfld.long 0x00 27. " IT227[3]  ,Interrupt Target 227 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT227[2]  ,Interrupt Target 227 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT227[1]  ,Interrupt Target 227 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT227[0]  ,Interrupt Target 227 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT226[3] ,Interrupt Target 226 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT226[2] ,Interrupt Target 226 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT226[1]  ,Interrupt Target 226 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT226[0]  ,Interrupt Target 226 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT225[3]  ,Interrupt Target 225 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT225[2]  ,Interrupt Target 225 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT225[1] ,Interrupt Target 225 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT225[0] ,Interrupt Target 225 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT224[3]  ,Interrupt Target 224 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT224[2]  ,Interrupt Target 224 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT224[1]  ,Interrupt Target 224 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT224[0]  ,Interrupt Target 224 SPI CPU0" "0,1"
group.long 0x8E4++0x03
    line.long 0x00 "ICDIPTR57,Interrupt SPI Target Register 57"
        bitfld.long 0x00 27. " IT231[3]  ,Interrupt Target 231 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT231[2]  ,Interrupt Target 231 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT231[1]  ,Interrupt Target 231 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT231[0]  ,Interrupt Target 231 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT230[3] ,Interrupt Target 230 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT230[2] ,Interrupt Target 230 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT230[1]  ,Interrupt Target 230 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT230[0]  ,Interrupt Target 230 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT229[3]  ,Interrupt Target 229 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT229[2]  ,Interrupt Target 229 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT229[1] ,Interrupt Target 229 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT229[0] ,Interrupt Target 229 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT228[3]  ,Interrupt Target 228 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT228[2]  ,Interrupt Target 228 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT228[1]  ,Interrupt Target 228 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT228[0]  ,Interrupt Target 228 SPI CPU0" "0,1"
group.long 0x8E8++0x03
    line.long 0x00 "ICDIPTR58,Interrupt SPI Target Register 58"
        bitfld.long 0x00 27. " IT235[3]  ,Interrupt Target 235 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT235[2]  ,Interrupt Target 235 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT235[1]  ,Interrupt Target 235 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT235[0]  ,Interrupt Target 235 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT234[3] ,Interrupt Target 234 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT234[2] ,Interrupt Target 234 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT234[1]  ,Interrupt Target 234 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT234[0]  ,Interrupt Target 234 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT233[3]  ,Interrupt Target 233 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT233[2]  ,Interrupt Target 233 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT233[1] ,Interrupt Target 233 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT233[0] ,Interrupt Target 233 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT232[3]  ,Interrupt Target 232 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT232[2]  ,Interrupt Target 232 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT232[1]  ,Interrupt Target 232 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT232[0]  ,Interrupt Target 232 SPI CPU0" "0,1"
group.long 0x8EC++0x03
    line.long 0x00 "ICDIPTR59,Interrupt SPI Target Register 59"
        bitfld.long 0x00 27. " IT239[3]  ,Interrupt Target 239 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT239[2]  ,Interrupt Target 239 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT239[1]  ,Interrupt Target 239 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT239[0]  ,Interrupt Target 239 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT238[3] ,Interrupt Target 238 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT238[2] ,Interrupt Target 238 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT238[1]  ,Interrupt Target 238 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT238[0]  ,Interrupt Target 238 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT237[3]  ,Interrupt Target 237 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT237[2]  ,Interrupt Target 237 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT237[1] ,Interrupt Target 237 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT237[0] ,Interrupt Target 237 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT236[3]  ,Interrupt Target 236 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT236[2]  ,Interrupt Target 236 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT236[1]  ,Interrupt Target 236 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT236[0]  ,Interrupt Target 236 SPI CPU0" "0,1"
group.long 0x8F0++0x03
    line.long 0x00 "ICDIPTR60,Interrupt SPI Target Register 60"
        bitfld.long 0x00 27. " IT243[3]  ,Interrupt Target 243 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT243[2]  ,Interrupt Target 243 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT243[1]  ,Interrupt Target 243 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT243[0]  ,Interrupt Target 243 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT242[3] ,Interrupt Target 242 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT242[2] ,Interrupt Target 242 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT242[1]  ,Interrupt Target 242 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT242[0]  ,Interrupt Target 242 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT241[3]  ,Interrupt Target 241 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT241[2]  ,Interrupt Target 241 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT241[1] ,Interrupt Target 241 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT241[0] ,Interrupt Target 241 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT240[3]  ,Interrupt Target 240 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT240[2]  ,Interrupt Target 240 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT240[1]  ,Interrupt Target 240 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT240[0]  ,Interrupt Target 240 SPI CPU0" "0,1"
group.long 0x8F4++0x03
    line.long 0x00 "ICDIPTR61,Interrupt SPI Target Register 61"
        bitfld.long 0x00 27. " IT247[3]  ,Interrupt Target 247 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT247[2]  ,Interrupt Target 247 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT247[1]  ,Interrupt Target 247 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT247[0]  ,Interrupt Target 247 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT246[3] ,Interrupt Target 246 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT246[2] ,Interrupt Target 246 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT246[1]  ,Interrupt Target 246 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT246[0]  ,Interrupt Target 246 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT245[3]  ,Interrupt Target 245 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT245[2]  ,Interrupt Target 245 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT245[1] ,Interrupt Target 245 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT245[0] ,Interrupt Target 245 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT244[3]  ,Interrupt Target 244 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT244[2]  ,Interrupt Target 244 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT244[1]  ,Interrupt Target 244 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT244[0]  ,Interrupt Target 244 SPI CPU0" "0,1"
group.long 0x8F8++0x03
    line.long 0x00 "ICDIPTR62,Interrupt SPI Target Register 62"
        bitfld.long 0x00 27. " IT251[3]  ,Interrupt Target 251 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT251[2]  ,Interrupt Target 251 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT251[1]  ,Interrupt Target 251 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT251[0]  ,Interrupt Target 251 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT250[3] ,Interrupt Target 250 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT250[2] ,Interrupt Target 250 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT250[1]  ,Interrupt Target 250 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT250[0]  ,Interrupt Target 250 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT249[3]  ,Interrupt Target 249 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT249[2]  ,Interrupt Target 249 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT249[1] ,Interrupt Target 249 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT249[0] ,Interrupt Target 249 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT248[3]  ,Interrupt Target 248 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT248[2]  ,Interrupt Target 248 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT248[1]  ,Interrupt Target 248 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT248[0]  ,Interrupt Target 248 SPI CPU0" "0,1"
group.long 0x8FC++0x03
    line.long 0x00 "ICDIPTR63,Interrupt SPI Target Register 63"
        bitfld.long 0x00 27. " IT255[3]  ,Interrupt Target 255 SPI CPU3" "0,1"
        bitfld.long 0x00 26. "  IT255[2]  ,Interrupt Target 255 SPI CPU2" "0,1"
        bitfld.long 0x00 25. "  IT255[1]  ,Interrupt Target 255 SPI CPU1" "0,1"
        bitfld.long 0x00 24. "  IT255[0]  ,Interrupt Target 255 SPI CPU0" "0,1"
        bitfld.long 0x00 19. "  IT254[3] ,Interrupt Target 254 SPI CPU3" "0,1"
        bitfld.long 0x00 18. "  IT254[2] ,Interrupt Target 254 SPI CPU2" "0,1"
        textline "                     "
        bitfld.long 0x00 17. " IT254[1]  ,Interrupt Target 254 SPI CPU1" "0,1"
        bitfld.long 0x00 16. "  IT254[0]  ,Interrupt Target 254 SPI CPU0" "0,1"
        bitfld.long 0x00 11. "  IT253[3]  ,Interrupt Target 253 SPI CPU3" "0,1"
        bitfld.long 0x00 10. "  IT253[2]  ,Interrupt Target 253 SPI CPU2" "0,1"
        bitfld.long 0x00 9. "  IT253[1] ,Interrupt Target 253 SPI CPU1" "0,1"
        bitfld.long 0x00 8. "  IT253[0] ,Interrupt Target 253 SPI CPU0" "0,1"
        textline "                     "
        bitfld.long 0x00 3. " IT252[3]  ,Interrupt Target 252 SPI CPU3" "0,1"
        bitfld.long 0x00 2. "  IT252[2]  ,Interrupt Target 252 SPI CPU2" "0,1"
        bitfld.long 0x00 1. "  IT252[1]  ,Interrupt Target 252 SPI CPU1" "0,1"
        bitfld.long 0x00 0. "  IT252[0]  ,Interrupt Target 252 SPI CPU0" "0,1"
tree.end
width 10.
tree "Interrupt Configuration Registers"
group.long 0xc00++0x03
    line.long 0x00 "ICDICR0,Interrupt Configuration STI Register"
        bitfld.long 0x00 30.--31. " ITCS[15] ,Interrupt Configuration STI[15]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITCS[14] ,Interrupt Configuration STI[14]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITCS[13] ,Interrupt Configuration STI[13]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITCS[12] ,Interrupt Configuration STI[12]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITCS[11] ,Interrupt Configuration STI[11]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITCS[10] ,Interrupt Configuration STI[10]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITCS[9]  ,Interrupt Configuration STI[9]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITCS[8]  ,Interrupt Configuration STI[8]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITCS[7]  ,Interrupt Configuration STI[7]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITCS[6]  ,Interrupt Configuration STI[6]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITCS[5]  ,Interrupt Configuration STI[5]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITCS[4]  ,Interrupt Configuration STI[4]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITCS[3]  ,Interrupt Configuration STI[3]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITCS[2]  ,Interrupt Configuration STI[2]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITCS[1]  ,Interrupt Configuration STI[1]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITCS[0]  ,Interrupt Configuration STI[0]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
group.long 0xc04++0x03
    line.long 0x00 "ICDICR1,Interrupt Configuration PPI Register"
        bitfld.long 0x00 30.--31. " ITCP[4]  ,Interrupt Configuration PPI[4]" "Reserved,1-N software/Level high,Reserved,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITCP[3]  ,Interrupt Configuration PPI[3]" "Reserved,1-N software/Level high,Reserved,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITCP[2]  ,Interrupt Configuration PPI[2]" "Reserved,1-N software/Level high,Reserved,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITCP[1]  ,Interrupt Configuration PPI[1]" "Reserved,1-N software/Level high,Reserved,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITCP[0]  ,Interrupt Configuration PPI[0]" "Reserved,1-N software/Level high,Reserved,1-N software/Rising edge"
group.long 0xc08++0x03
    line.long 0x00 "ICDICR2,Interrupt Configuration SPI Register 0"
        bitfld.long 0x00 30.--31. " ITC[15]  ,Interrupt Configuration SPI[15]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[14]  ,Interrupt Configuration SPI[14]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[13]  ,Interrupt Configuration SPI[13]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[12]  ,Interrupt Configuration SPI[12]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[11]  ,Interrupt Configuration SPI[11]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[10]  ,Interrupt Configuration SPI[10]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[9]   ,Interrupt Configuration SPI[9]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[8]   ,Interrupt Configuration SPI[8]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[7]   ,Interrupt Configuration SPI[7]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[6]   ,Interrupt Configuration SPI[6]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[5]   ,Interrupt Configuration SPI[5]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[4]   ,Interrupt Configuration SPI[4]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[3]   ,Interrupt Configuration SPI[3]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[2]   ,Interrupt Configuration SPI[2]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[1]   ,Interrupt Configuration SPI[1]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[0]   ,Interrupt Configuration SPI[0]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"

group.long 0xc0c++0x03
    line.long 0x00 "ICDICR3,Interrupt Configuration SPI Register 3"
        bitfld.long 0x00 30.--31. " ITC[31]  ,Interrupt Configuration SPI[31]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[30]  ,Interrupt Configuration SPI[30]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[29]  ,Interrupt Configuration SPI[29]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[28]  ,Interrupt Configuration SPI[28]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[27]  ,Interrupt Configuration SPI[27]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[26]  ,Interrupt Configuration SPI[26]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[25]  ,Interrupt Configuration SPI[25]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[24]  ,Interrupt Configuration SPI[24]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[23]  ,Interrupt Configuration SPI[23]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[22]  ,Interrupt Configuration SPI[22]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[21]  ,Interrupt Configuration SPI[21]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[20]  ,Interrupt Configuration SPI[20]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[19]  ,Interrupt Configuration SPI[19]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[18]  ,Interrupt Configuration SPI[18]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[17]  ,Interrupt Configuration SPI[17]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[16]  ,Interrupt Configuration SPI[16]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"        
group.long 0xc10++0x03
    line.long 0x00 "ICDICR4,Interrupt Configuration SPI Register 4"
        bitfld.long 0x00 30.--31. " ITC[47]  ,Interrupt Configuration SPI[47]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[46]  ,Interrupt Configuration SPI[46]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[45]  ,Interrupt Configuration SPI[45]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[44]  ,Interrupt Configuration SPI[44]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[43]  ,Interrupt Configuration SPI[43]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[42]  ,Interrupt Configuration SPI[42]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[41]  ,Interrupt Configuration SPI[41]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[40]  ,Interrupt Configuration SPI[40]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[39]  ,Interrupt Configuration SPI[39]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[38]  ,Interrupt Configuration SPI[38]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[37]  ,Interrupt Configuration SPI[37]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[36]  ,Interrupt Configuration SPI[36]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[35]  ,Interrupt Configuration SPI[35]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[34]  ,Interrupt Configuration SPI[34]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[33]  ,Interrupt Configuration SPI[33]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[32]  ,Interrupt Configuration SPI[32]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"        
group.long 0xc14++0x03
    line.long 0x00 "ICDICR5,Interrupt Configuration SPI Register 5"
        bitfld.long 0x00 30.--31. " ITC[63]  ,Interrupt Configuration SPI[63]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[62]  ,Interrupt Configuration SPI[62]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[61]  ,Interrupt Configuration SPI[61]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[60]  ,Interrupt Configuration SPI[60]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[59]  ,Interrupt Configuration SPI[59]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[58]  ,Interrupt Configuration SPI[58]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[57]  ,Interrupt Configuration SPI[57]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[56]  ,Interrupt Configuration SPI[56]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[55]  ,Interrupt Configuration SPI[55]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[54]  ,Interrupt Configuration SPI[54]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[53]  ,Interrupt Configuration SPI[53]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[52]  ,Interrupt Configuration SPI[52]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[51]  ,Interrupt Configuration SPI[51]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[50]  ,Interrupt Configuration SPI[50]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[49]  ,Interrupt Configuration SPI[49]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[48]  ,Interrupt Configuration SPI[48]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"    
group.long 0xc18++0x03
    line.long 0x00 "ICDICR6,Interrupt Configuration SPI Register 6"
        bitfld.long 0x00 30.--31. " ITC[79]  ,Interrupt Configuration SPI[79]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[78]  ,Interrupt Configuration SPI[78]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[77]  ,Interrupt Configuration SPI[77]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[76]  ,Interrupt Configuration SPI[76]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[75]  ,Interrupt Configuration SPI[75]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[74]  ,Interrupt Configuration SPI[74]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[73]  ,Interrupt Configuration SPI[73]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[72]  ,Interrupt Configuration SPI[72]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[71]  ,Interrupt Configuration SPI[71]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[70]  ,Interrupt Configuration SPI[70]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[69]  ,Interrupt Configuration SPI[69]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[68]  ,Interrupt Configuration SPI[68]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[67]  ,Interrupt Configuration SPI[67]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[66]  ,Interrupt Configuration SPI[66]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[65]  ,Interrupt Configuration SPI[65]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[64]  ,Interrupt Configuration SPI[64]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"    
group.long 0xc1c++0x03
    line.long 0x00 "ICDICR7,Interrupt Configuration SPI Register 7"
        bitfld.long 0x00 30.--31. " ITC[95]  ,Interrupt Configuration SPI[95]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[94]  ,Interrupt Configuration SPI[94]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[93]  ,Interrupt Configuration SPI[93]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[92]  ,Interrupt Configuration SPI[92]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[91]  ,Interrupt Configuration SPI[91]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[90]  ,Interrupt Configuration SPI[90]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[89]  ,Interrupt Configuration SPI[89]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[88]  ,Interrupt Configuration SPI[88]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[87]  ,Interrupt Configuration SPI[87]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[86]  ,Interrupt Configuration SPI[86]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[85]  ,Interrupt Configuration SPI[85]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[84]  ,Interrupt Configuration SPI[84]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[83]  ,Interrupt Configuration SPI[83]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[82]  ,Interrupt Configuration SPI[82]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[81]  ,Interrupt Configuration SPI[81]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[80]  ,Interrupt Configuration SPI[80]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"    
group.long 0xc20++0x03
    line.long 0x00 "ICDICR8,Interrupt Configuration SPI Register 8"
        bitfld.long 0x00 30.--31. " ITC[111] ,Interrupt Configuration SPI[111]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[110] ,Interrupt Configuration SPI[110]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[109] ,Interrupt Configuration SPI[109]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[108] ,Interrupt Configuration SPI[108]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[107] ,Interrupt Configuration SPI[107]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[106] ,Interrupt Configuration SPI[106]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[105] ,Interrupt Configuration SPI[105]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[104] ,Interrupt Configuration SPI[104]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[103] ,Interrupt Configuration SPI[103]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[102] ,Interrupt Configuration SPI[102]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[101] ,Interrupt Configuration SPI[101]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[100] ,Interrupt Configuration SPI[100]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[99]  ,Interrupt Configuration SPI[99]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[98]  ,Interrupt Configuration SPI[98]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[97]  ,Interrupt Configuration SPI[97]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[96]  ,Interrupt Configuration SPI[96]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"    
group.long 0xc24++0x03
    line.long 0x00 "ICDICR9,Interrupt Configuration SPI Register 9"
        bitfld.long 0x00 30.--31. " ITC[127] ,Interrupt Configuration SPI[127]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[126] ,Interrupt Configuration SPI[126]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[125] ,Interrupt Configuration SPI[125]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[124] ,Interrupt Configuration SPI[124]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[123] ,Interrupt Configuration SPI[123]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[122] ,Interrupt Configuration SPI[122]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[121] ,Interrupt Configuration SPI[121]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[120] ,Interrupt Configuration SPI[120]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[119] ,Interrupt Configuration SPI[119]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[118] ,Interrupt Configuration SPI[118]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[117] ,Interrupt Configuration SPI[117]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[116] ,Interrupt Configuration SPI[116]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[115] ,Interrupt Configuration SPI[115]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[114] ,Interrupt Configuration SPI[114]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[113] ,Interrupt Configuration SPI[113]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[112] ,Interrupt Configuration SPI[112]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"    
group.long 0xc28++0x03
    line.long 0x00 "ICDICR10,Interrupt Configuration SPI Register 10"
        bitfld.long 0x00 30.--31. " ITC[143] ,Interrupt Configuration SPI[143]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[142] ,Interrupt Configuration SPI[142]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[141] ,Interrupt Configuration SPI[141]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[140] ,Interrupt Configuration SPI[140]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[139] ,Interrupt Configuration SPI[139]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[138] ,Interrupt Configuration SPI[138]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[137] ,Interrupt Configuration SPI[137]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[136] ,Interrupt Configuration SPI[136]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[135] ,Interrupt Configuration SPI[135]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[134] ,Interrupt Configuration SPI[134]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[133] ,Interrupt Configuration SPI[133]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[132] ,Interrupt Configuration SPI[132]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[131] ,Interrupt Configuration SPI[131]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[130] ,Interrupt Configuration SPI[130]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[129] ,Interrupt Configuration SPI[129]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[128] ,Interrupt Configuration SPI[128]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"    
group.long 0xc2c++0x03
    line.long 0x00 "ICDICR11,Interrupt Configuration SPI Register 11"
        bitfld.long 0x00 30.--31. " ITC[159] ,Interrupt Configuration SPI[159]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[158] ,Interrupt Configuration SPI[158]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[157] ,Interrupt Configuration SPI[157]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[156] ,Interrupt Configuration SPI[156]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[155] ,Interrupt Configuration SPI[155]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[154] ,Interrupt Configuration SPI[154]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[153] ,Interrupt Configuration SPI[153]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[152] ,Interrupt Configuration SPI[152]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[151] ,Interrupt Configuration SPI[151]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[150] ,Interrupt Configuration SPI[150]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[149] ,Interrupt Configuration SPI[149]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[148] ,Interrupt Configuration SPI[148]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[147] ,Interrupt Configuration SPI[147]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[146] ,Interrupt Configuration SPI[146]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[145] ,Interrupt Configuration SPI[145]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[144] ,Interrupt Configuration SPI[144]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"    
group.long 0xc30++0x03
    line.long 0x00 "ICDICR12,Interrupt Configuration SPI Register 12"
        bitfld.long 0x00 30.--31. " ITC[175] ,Interrupt Configuration SPI[175]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[174] ,Interrupt Configuration SPI[174]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[173] ,Interrupt Configuration SPI[173]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[172] ,Interrupt Configuration SPI[172]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[171] ,Interrupt Configuration SPI[171]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[170] ,Interrupt Configuration SPI[170]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[169] ,Interrupt Configuration SPI[169]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[168] ,Interrupt Configuration SPI[168]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[167] ,Interrupt Configuration SPI[167]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[166] ,Interrupt Configuration SPI[166]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[165] ,Interrupt Configuration SPI[165]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[164] ,Interrupt Configuration SPI[164]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[163] ,Interrupt Configuration SPI[163]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[162] ,Interrupt Configuration SPI[162]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[161] ,Interrupt Configuration SPI[161]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[160] ,Interrupt Configuration SPI[160]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"    
group.long 0xc34++0x03
    line.long 0x00 "ICDICR13,Interrupt Configuration SPI Register 13"
        bitfld.long 0x00 30.--31. " ITC[191] ,Interrupt Configuration SPI[191]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[190] ,Interrupt Configuration SPI[190]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[189] ,Interrupt Configuration SPI[189]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[188] ,Interrupt Configuration SPI[188]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[187] ,Interrupt Configuration SPI[187]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[186] ,Interrupt Configuration SPI[186]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[185] ,Interrupt Configuration SPI[185]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[184] ,Interrupt Configuration SPI[184]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[183] ,Interrupt Configuration SPI[183]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[182] ,Interrupt Configuration SPI[182]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[181] ,Interrupt Configuration SPI[181]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[180] ,Interrupt Configuration SPI[180]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[179] ,Interrupt Configuration SPI[179]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[178] ,Interrupt Configuration SPI[178]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[177] ,Interrupt Configuration SPI[177]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[176] ,Interrupt Configuration SPI[176]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"            
group.long 0xc38++0x03
    line.long 0x00 "ICDICR14,Interrupt Configuration SPI Register 14"
        bitfld.long 0x00 30.--31. " ITC[207] ,Interrupt Configuration SPI[207]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[206] ,Interrupt Configuration SPI[206]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[205] ,Interrupt Configuration SPI[205]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[204] ,Interrupt Configuration SPI[204]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[203] ,Interrupt Configuration SPI[203]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[202] ,Interrupt Configuration SPI[202]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[201] ,Interrupt Configuration SPI[201]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[200] ,Interrupt Configuration SPI[200]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[199] ,Interrupt Configuration SPI[199]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[198] ,Interrupt Configuration SPI[198]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[197] ,Interrupt Configuration SPI[197]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[196] ,Interrupt Configuration SPI[196]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[195] ,Interrupt Configuration SPI[195]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[194] ,Interrupt Configuration SPI[194]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[193] ,Interrupt Configuration SPI[193]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[192] ,Interrupt Configuration SPI[192]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"            
group.long 0xc3c++0x03
    line.long 0x00 "ICDICR15,Interrupt Configuration SPI Register 15"
        bitfld.long 0x00 30.--31. " ITC[223] ,Interrupt Configuration SPI[223]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 28.--29. "  ITC[222] ,Interrupt Configuration SPI[222]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 26.--27. " ITC[221] ,Interrupt Configuration SPI[221]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 24.--25. "  ITC[220] ,Interrupt Configuration SPI[220]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 22.--23. " ITC[219] ,Interrupt Configuration SPI[219]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 20.--21. "  ITC[218] ,Interrupt Configuration SPI[218]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 18.--19. " ITC[217] ,Interrupt Configuration SPI[217]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 16.--17. "  ITC[216] ,Interrupt Configuration SPI[216]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 14.--15. " ITC[215] ,Interrupt Configuration SPI[215]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 12.--13. "  ITC[214] ,Interrupt Configuration SPI[214]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 10.--11. " ITC[213] ,Interrupt Configuration SPI[213]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 8.--9. "  ITC[212] ,Interrupt Configuration SPI[212]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 6.--7. " ITC[211] ,Interrupt Configuration SPI[211]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 4.--5. "  ITC[210] ,Interrupt Configuration SPI[210]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        textline "                   "
        bitfld.long 0x00 2.--3. " ITC[209] ,Interrupt Configuration SPI[209]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"
        bitfld.long 0x00 0.--1. "  ITC[208] ,Interrupt Configuration SPI[208]" "N-N software/Level high,1-N software/Level high,N-N software/Rising edge,1-N software/Rising edge"            
textline "                 "
width 8.
group.long 0xd00++0x03
    line.long 0x00 "PPISR,PPI Status Register"
        bitfld.long 0x00 15. " PPI[3]   ,PPI[3] Status" "Low,High"
        bitfld.long 0x00 14. "  PPI[2]   ,PPI[2] Status" "Low,High"
        bitfld.long 0x00 13. "  PPI[1]   ,PPI[1] Status" "Low,High"
        bitfld.long 0x00 12. "  PPI[0]   ,PPI[0] Status" "Low,High"
        bitfld.long 0x00 11. "  PPI[4]   ,PPI[4] Status" "Low,High"
group.long 0xd04++0x03
    line.long 0x00 "SPISR0,SPI Status Register 0"    
        bitfld.long 0x00 31. " SPI[31]  ,SPI Status[31]" "Low,High"
        bitfld.long 0x00 30. "  SPI[30]  ,SPI Status[30]" "Low,High"
        bitfld.long 0x00 29. "  SPI[29]  ,SPI Status[29]" "Low,High"
        bitfld.long 0x00 28. "  SPI[28]  ,SPI Status[28]" "Low,High"
        bitfld.long 0x00 27. "  SPI[27]  ,SPI Status[27]" "Low,High"
        textline "                 "
        bitfld.long 0x00 26. " SPI[26]  ,SPI Status[26]" "Low,High"
        bitfld.long 0x00 25. "  SPI[25]  ,SPI Status[25]" "Low,High"
        bitfld.long 0x00 24. "  SPI[24]  ,SPI Status[24]" "Low,High"
        bitfld.long 0x00 23. "  SPI[23]  ,SPI Status[23]" "Low,High"
        bitfld.long 0x00 22. "  SPI[22]  ,SPI Status[22]" "Low,High"
        textline "                 "
        bitfld.long 0x00 21. " SPI[21]  ,SPI Status[21]" "Low,High"
        bitfld.long 0x00 20. "  SPI[20]  ,SPI Status[20]" "Low,High"
        bitfld.long 0x00 19. "  SPI[19]  ,SPI Status[19]" "Low,High"
        bitfld.long 0x00 18. "  SPI[18]  ,SPI Status[18]" "Low,High"
        bitfld.long 0x00 17. "  SPI[17]  ,SPI Status[17]" "Low,High"
        textline "                 "
        bitfld.long 0x00 16. " SPI[16]  ,SPI Status[16]" "Low,High"
        bitfld.long 0x00 15. "  SPI[15]  ,SPI Status[15]" "Low,High"
        bitfld.long 0x00 14. "  SPI[14]  ,SPI Status[14]" "Low,High"
        bitfld.long 0x00 13. "  SPI[13]  ,SPI Status[13]" "Low,High"
        bitfld.long 0x00 12. "  SPI[12]  ,SPI Status[12]" "Low,High"
        textline "                 "
        bitfld.long 0x00 11. " SPI[11]  ,SPI Status[11]" "Low,High"
        bitfld.long 0x00 10. "  SPI[19]  ,SPI Status[10]" "Low,High"
        bitfld.long 0x00 9. "  SPI[9]   ,SPI Status[9]" "Low,High"
        bitfld.long 0x00 8. "  SPI[8]   ,SPI Status[8]" "Low,High"
        bitfld.long 0x00 7. "  SPI[7]   ,SPI Status[7]" "Low,High"
        textline "                 "
        bitfld.long 0x00 6. " SPI[6]   ,SPI Status[6]" "Low,High"
        bitfld.long 0x00 5. "  SPI[5]   ,SPI Status[5]" "Low,High"
        bitfld.long 0x00 4. "  SPI[4]   ,SPI Status[4]" "Low,High"
        bitfld.long 0x00 3. "  SPI[3]   ,SPI Status[3]" "Low,High"
        bitfld.long 0x00 2. "  SPI[2]   ,SPI Status[2]" "Low,High"
        textline "                 "
        bitfld.long 0x00 1. " SPI[1]   ,SPI Status[1]" "Low,High"
        bitfld.long 0x00 0. "  SPI[0]   ,SPI Status[0]" "Low,High"
group.long 0xd08++0x03
    line.long 0x00 "SPISR1,SPI Status Register 1"
        bitfld.long 0x00 31. " SPI[63]  ,SPI Status[63]" "Low,High"
        bitfld.long 0x00 30. "  SPI[62]  ,SPI Status[62]" "Low,High"
        bitfld.long 0x00 29. "  SPI[61]  ,SPI Status[61]" "Low,High"
        bitfld.long 0x00 28. "  SPI[60]  ,SPI Status[60]" "Low,High"
        bitfld.long 0x00 27. "  SPI[59]  ,SPI Status[59]" "Low,High"
        textline "                 "
        bitfld.long 0x00 26. " SPI[58]  ,SPI Status[58]" "Low,High"
        bitfld.long 0x00 25. "  SPI[57]  ,SPI Status[57]" "Low,High"
        bitfld.long 0x00 24. "  SPI[56]  ,SPI Status[56]" "Low,High"
        bitfld.long 0x00 23. "  SPI[55]  ,SPI Status[55]" "Low,High"
        bitfld.long 0x00 22. "  SPI[54]  ,SPI Status[54]" "Low,High"
        textline "                 "
        bitfld.long 0x00 21. " SPI[53]  ,SPI Status[53]" "Low,High"
        bitfld.long 0x00 20. "  SPI[52]  ,SPI Status[52]" "Low,High"
        bitfld.long 0x00 19. "  SPI[51]  ,SPI Status[51]" "Low,High"
        bitfld.long 0x00 18. "  SPI[50]  ,SPI Status[50]" "Low,High"
        bitfld.long 0x00 17. "  SPI[49]  ,SPI Status[49]" "Low,High"
        textline "                 "
        bitfld.long 0x00 16. " SPI[48]  ,SPI Status[48]" "Low,High"
        bitfld.long 0x00 15. "  SPI[47]  ,SPI Status[47]" "Low,High"
        bitfld.long 0x00 14. "  SPI[46]  ,SPI Status[46]" "Low,High"
        bitfld.long 0x00 13. "  SPI[45]  ,SPI Status[45]" "Low,High"
        bitfld.long 0x00 12. "  SPI[44]  ,SPI Status[44]" "Low,High"
        textline "                 "
        bitfld.long 0x00 11. " SPI[43]  ,SPI Status[43]" "Low,High"
        bitfld.long 0x00 10. "  SPI[42]  ,SPI Status[42]" "Low,High"
        bitfld.long 0x00 9. "  SPI[41]  ,SPI Status[41]" "Low,High"
        bitfld.long 0x00 8. "  SPI[40]  ,SPI Status[40]" "Low,High"
        bitfld.long 0x00 7. "  SPI[39]  ,SPI Status[39]" "Low,High"
        textline "                 "
        bitfld.long 0x00 6. " SPI[38]  ,SPI Status[38]" "Low,High"
        bitfld.long 0x00 5. "  SPI[37]  ,SPI Status[37]" "Low,High"
        bitfld.long 0x00 4. "  SPI[36]  ,SPI Status[36]" "Low,High"
        bitfld.long 0x00 3. "  SPI[35]  ,SPI Status[35]" "Low,High"
        textline "                 "
        bitfld.long 0x00 2. " SPI[34]  ,SPI Status[34]" "Low,High"
        bitfld.long 0x00 1. "  SPI[33]  ,SPI Status[33]" "Low,High"
        bitfld.long 0x00 0. "  SPI[32]  ,SPI Status[32]" "Low,High"
group.long 0xd0C++0x03
    line.long 0x00 "SPISR2,SPI Status Register 2"
        bitfld.long 0x00 31. " SPI[95]  ,SPI Status[95]" "Low,High"
        bitfld.long 0x00 30. "  SPI[94]  ,SPI Status[94]" "Low,High"
        bitfld.long 0x00 29. "  SPI[93]  ,SPI Status[93]" "Low,High"
        bitfld.long 0x00 28. "  SPI[92]  ,SPI Status[92]" "Low,High"
        bitfld.long 0x00 27. "  SPI[91]  ,SPI Status[91]" "Low,High"
        textline "                 "
        bitfld.long 0x00 26. " SPI[90]  ,SPI Status[90]" "Low,High"
        bitfld.long 0x00 25. "  SPI[89]  ,SPI Status[89]" "Low,High"
        bitfld.long 0x00 24. "  SPI[88]  ,SPI Status[88]" "Low,High"
        bitfld.long 0x00 23. "  SPI[87]  ,SPI Status[87]" "Low,High"
        bitfld.long 0x00 22. "  SPI[86]  ,SPI Status[86]" "Low,High"
        textline "                 "
        bitfld.long 0x00 21. " SPI[85]  ,SPI Status[85]" "Low,High"
        bitfld.long 0x00 20. "  SPI[84]  ,SPI Status[84]" "Low,High"
        bitfld.long 0x00 19. "  SPI[83]  ,SPI Status[83]" "Low,High"
        bitfld.long 0x00 18. "  SPI[82]  ,SPI Status[82]" "Low,High"
        bitfld.long 0x00 17. "  SPI[81]  ,SPI Status[81]" "Low,High"
        textline "                 "
        bitfld.long 0x00 16. " SPI[80]  ,SPI Status[80]" "Low,High"
        bitfld.long 0x00 15. "  SPI[79]  ,SPI Status[79]" "Low,High"
        bitfld.long 0x00 14. "  SPI[78]  ,SPI Status[78]" "Low,High"
        bitfld.long 0x00 13. "  SPI[77]  ,SPI Status[77]" "Low,High"
        bitfld.long 0x00 12. "  SPI[76]  ,SPI Status[76]" "Low,High"
        textline "                 "
        bitfld.long 0x00 11. " SPI[75]  ,SPI Status[75]" "Low,High"
        bitfld.long 0x00 10. "  SPI[74]  ,SPI Status[74]" "Low,High"
        bitfld.long 0x00 9. "  SPI[73]  ,SPI Status[73]" "Low,High"
        bitfld.long 0x00 8. "  SPI[72]  ,SPI Status[72]" "Low,High"
        bitfld.long 0x00 7. "  SPI[71]  ,SPI Status[71]" "Low,High"
        textline "                 "
        bitfld.long 0x00 6. " SPI[70]  ,SPI Status[70]" "Low,High"
        bitfld.long 0x00 5. "  SPI[69]  ,SPI Status[69]" "Low,High"
        bitfld.long 0x00 4. "  SPI[68]  ,SPI Status[68]" "Low,High"
        bitfld.long 0x00 3. "  SPI[67]  ,SPI Status[67]" "Low,High"
        bitfld.long 0x00 2. "  SPI[66]  ,SPI Status[66]" "Low,High"
        textline "                 "
        bitfld.long 0x00 1. " SPI[65]  ,SPI Status[65]" "Low,High"
        bitfld.long 0x00 0. "  SPI[64]  ,SPI Status[64]" "Low,High"        
group.long 0xd10++0x03
    line.long 0x00 "SPISR3,SPI Status Register 3"
        bitfld.long 0x00 31. " SPI[127] ,SPI Status[127]" "Low,High"
        bitfld.long 0x00 30. "  SPI[126] ,SPI Status[126]" "Low,High"
        bitfld.long 0x00 29. "  SPI[125] ,SPI Status[125]" "Low,High"
        bitfld.long 0x00 28. "  SPI[124] ,SPI Status[124]" "Low,High"
        bitfld.long 0x00 27. "  SPI[123] ,SPI Status[123]" "Low,High"
        textline "                 "
        bitfld.long 0x00 26. " SPI[122] ,SPI Status[122]" "Low,High"
        bitfld.long 0x00 25. "  SPI[121] ,SPI Status[121]" "Low,High"
        bitfld.long 0x00 24. "  SPI[120] ,SPI Status[120]" "Low,High"
        bitfld.long 0x00 23. "  SPI[119] ,SPI Status[119]" "Low,High"
        bitfld.long 0x00 22. "  SPI[118] ,SPI Status[118]" "Low,High"
        textline "                 "
        bitfld.long 0x00 21. " SPI[117] ,SPI Status[117]" "Low,High"
        bitfld.long 0x00 20. "  SPI[116] ,SPI Status[116]" "Low,High"
        bitfld.long 0x00 19. "  SPI[115] ,SPI Status[115]" "Low,High"
        bitfld.long 0x00 18. "  SPI[114] ,SPI Status[114]" "Low,High"
        bitfld.long 0x00 17. "  SPI[113] ,SPI Status[113]" "Low,High"
        textline "                 "
        bitfld.long 0x00 16. " SPI[112] ,SPI Status[112]" "Low,High"
        bitfld.long 0x00 15. "  SPI[111] ,SPI Status[111]" "Low,High"
        bitfld.long 0x00 14. "  SPI[110] ,SPI Status[110]" "Low,High"
        bitfld.long 0x00 13. "  SPI[109] ,SPI Status[109]" "Low,High"
        bitfld.long 0x00 12. "  SPI[108] ,SPI Status[108]" "Low,High"
        textline "                 "
        bitfld.long 0x00 11. " SPI[107] ,SPI Status[107]" "Low,High"
        bitfld.long 0x00 10. "  SPI[106] ,SPI Status[106]" "Low,High"
        bitfld.long 0x00 9. "  SPI[105] ,SPI Status[105]" "Low,High"
        bitfld.long 0x00 8. "  SPI[104] ,SPI Status[104]" "Low,High"
        bitfld.long 0x00 7. "  SPI[103] ,SPI Status[103]" "Low,High"
        textline "                 "
        bitfld.long 0x00 6. " SPI[102] ,SPI Status[102]" "Low,High"
        bitfld.long 0x00 5. "  SPI[101] ,SPI Status[101]" "Low,High"
        bitfld.long 0x00 4. "  SPI[100] ,SPI Status[100]" "Low,High"
        bitfld.long 0x00 3. "  SPI[99]  ,SPI Status[99]" "Low,High"
        bitfld.long 0x00 2. "  SPI[98]  ,SPI Status[98]" "Low,High"
        textline "                 "
        bitfld.long 0x00 1. " SPI[97]  ,SPI Status[97]" "Low,High"
        bitfld.long 0x00 0. "  SPI[96]  ,SPI Status[96]" "Low,High"        
group.long 0xd14++0x03
    line.long 0x00 "SPISR4,SPI Status Register 4"
        bitfld.long 0x00 31. " SPI[159] ,SPI Status[159]" "Low,High"
        bitfld.long 0x00 30. "  SPI[158] ,SPI Status[158]" "Low,High"
        bitfld.long 0x00 29. "  SPI[157] ,SPI Status[157]" "Low,High"
        bitfld.long 0x00 28. "  SPI[156] ,SPI Status[156]" "Low,High"
        bitfld.long 0x00 27. "  SPI[155] ,SPI Status[155]" "Low,High"
        textline "                 "
        bitfld.long 0x00 26. " SPI[154] ,SPI Status[154]" "Low,High"
        bitfld.long 0x00 25. "  SPI[153] ,SPI Status[153]" "Low,High"
        bitfld.long 0x00 24. "  SPI[152] ,SPI Status[152]" "Low,High"
        bitfld.long 0x00 23. "  SPI[151] ,SPI Status[151]" "Low,High"
        bitfld.long 0x00 22. "  SPI[150] ,SPI Status[150]" "Low,High"
        textline "                 "
        bitfld.long 0x00 21. " SPI[149] ,SPI Status[149]" "Low,High"
        bitfld.long 0x00 20. "  SPI[148] ,SPI Status[148]" "Low,High"
        bitfld.long 0x00 19. "  SPI[147] ,SPI Status[147]" "Low,High"
        bitfld.long 0x00 18. "  SPI[146] ,SPI Status[146]" "Low,High"
        bitfld.long 0x00 17. "  SPI[145] ,SPI Status[145]" "Low,High"
        textline "                 "
        bitfld.long 0x00 16. " SPI[144] ,SPI Status[144]" "Low,High"
        bitfld.long 0x00 15. "  SPI[143] ,SPI Status[143]" "Low,High"
        bitfld.long 0x00 14. "  SPI[142] ,SPI Status[142]" "Low,High"
        bitfld.long 0x00 13. "  SPI[141] ,SPI Status[141]" "Low,High"
        bitfld.long 0x00 12. "  SPI[140] ,SPI Status[140]" "Low,High"
        textline "                 "
        bitfld.long 0x00 11. " SPI[139] ,SPI Status[139]" "Low,High"
        bitfld.long 0x00 10. "  SPI[138] ,SPI Status[138]" "Low,High"
        bitfld.long 0x00 9. "  SPI[137] ,SPI Status[137]" "Low,High"
        bitfld.long 0x00 8. "  SPI[136] ,SPI Status[136]" "Low,High"
        bitfld.long 0x00 7. "  SPI[135] ,SPI Status[135]" "Low,High"
        textline "                 "
        bitfld.long 0x00 6. " SPI[134] ,SPI Status[134]" "Low,High"
        bitfld.long 0x00 5. "  SPI[133] ,SPI Status[133]" "Low,High"
        bitfld.long 0x00 4. "  SPI[132] ,SPI Status[132]" "Low,High"
        bitfld.long 0x00 3. "  SPI[131] ,SPI Status[131]" "Low,High"
        bitfld.long 0x00 2. "  SPI[130] ,SPI Status[130]" "Low,High"
        textline "                 "
        bitfld.long 0x00 1. " SPI[129] ,SPI Status[129]" "Low,High"
        bitfld.long 0x00 0. "  SPI[128] ,SPI Status[128]" "Low,High"    
group.long 0xd18++0x03
    line.long 0x00 "SPISR5,SPI Status Register 5"
        bitfld.long 0x00 31. " SPI[191] ,SPI Status[191]" "Low,High"
        bitfld.long 0x00 30. "  SPI[190] ,SPI Status[190]" "Low,High"
        bitfld.long 0x00 29. "  SPI[189] ,SPI Status[189]" "Low,High"
        bitfld.long 0x00 28. "  SPI[188] ,SPI Status[188]" "Low,High"
        bitfld.long 0x00 27. "  SPI[187] ,SPI Status[187]" "Low,High"
        textline "                 "
        bitfld.long 0x00 26. " SPI[186] ,SPI Status[186]" "Low,High"
        bitfld.long 0x00 25. "  SPI[185] ,SPI Status[185]" "Low,High"
        bitfld.long 0x00 24. "  SPI[184] ,SPI Status[184]" "Low,High"
        bitfld.long 0x00 23. "  SPI[183] ,SPI Status[183]" "Low,High"
        bitfld.long 0x00 22. "  SPI[182] ,SPI Status[182]" "Low,High"
        textline "                 "
        bitfld.long 0x00 21. " SPI[181] ,SPI Status[181]" "Low,High"
        bitfld.long 0x00 20. "  SPI[180] ,SPI Status[180]" "Low,High"
        bitfld.long 0x00 19. "  SPI[179] ,SPI Status[179]" "Low,High"
        bitfld.long 0x00 18. "  SPI[178] ,SPI Status[178]" "Low,High"
        bitfld.long 0x00 17. "  SPI[177] ,SPI Status[177]" "Low,High"
        textline "                 "
        bitfld.long 0x00 16. " SPI[176] ,SPI Status[176]" "Low,High"
        bitfld.long 0x00 15. "  SPI[175] ,SPI Status[175]" "Low,High"
        bitfld.long 0x00 14. "  SPI[174] ,SPI Status[174]" "Low,High"
        bitfld.long 0x00 13. "  SPI[173] ,SPI Status[173]" "Low,High"
        bitfld.long 0x00 12. "  SPI[172] ,SPI Status[172]" "Low,High"
        textline "                 "
        bitfld.long 0x00 11. " SPI[171] ,SPI Status[171]" "Low,High"
        bitfld.long 0x00 10. "  SPI[170] ,SPI Status[170]" "Low,High"
        bitfld.long 0x00 9. "  SPI[169] ,SPI Status[169]" "Low,High"
        bitfld.long 0x00 8. "  SPI[168] ,SPI Status[168]" "Low,High"
        bitfld.long 0x00 7. "  SPI[167] ,SPI Status[167]" "Low,High"
        textline "                 "
        bitfld.long 0x00 6. " SPI[166] ,SPI Status[166]" "Low,High"
        bitfld.long 0x00 5. "  SPI[165] ,SPI Status[165]" "Low,High"
        bitfld.long 0x00 4. "  SPI[164] ,SPI Status[164]" "Low,High"
        bitfld.long 0x00 3. "  SPI[163] ,SPI Status[163]" "Low,High"
        bitfld.long 0x00 2. "  SPI[162] ,SPI Status[162]" "Low,High"
        textline "                 "
        bitfld.long 0x00 1. " SPI[161] ,SPI Status[161]" "Low,High"
        bitfld.long 0x00 0. "  SPI[160] ,SPI Status[160]" "Low,High"        
group.long 0xd1c++0x03
    line.long 0x00 "SPISR6,SPI Status Register 6"
        bitfld.long 0x00 31. " SPI[223] ,SPI Status[223]" "Low,High"
        bitfld.long 0x00 30. "  SPI[222] ,SPI Status[222]" "Low,High"
        bitfld.long 0x00 29. "  SPI[221] ,SPI Status[221]" "Low,High"
        bitfld.long 0x00 28. "  SPI[220] ,SPI Status[220]" "Low,High"
        bitfld.long 0x00 27. "  SPI[219] ,SPI Status[219]" "Low,High"
        textline "                 "
        bitfld.long 0x00 26. " SPI[218] ,SPI Status[218]" "Low,High"
        bitfld.long 0x00 25. "  SPI[217] ,SPI Status[217]" "Low,High"
        bitfld.long 0x00 24. "  SPI[216] ,SPI Status[216]" "Low,High"
        bitfld.long 0x00 23. "  SPI[215] ,SPI Status[215]" "Low,High"
        bitfld.long 0x00 22. "  SPI[214] ,SPI Status[214]" "Low,High"
        textline "                 "
        bitfld.long 0x00 21. " SPI[213] ,SPI Status[213]" "Low,High"
        bitfld.long 0x00 20. "  SPI[212] ,SPI Status[212]" "Low,High"
        bitfld.long 0x00 19. "  SPI[211] ,SPI Status[211]" "Low,High"
        bitfld.long 0x00 18. "  SPI[210] ,SPI Status[210]" "Low,High"
        bitfld.long 0x00 17. "  SPI[209] ,SPI Status[209]" "Low,High"
        textline "                 "
        bitfld.long 0x00 16. " SPI[208] ,SPI Status[208]" "Low,High"
        bitfld.long 0x00 15. "  SPI[207] ,SPI Status[207]" "Low,High"
        bitfld.long 0x00 14. "  SPI[206] ,SPI Status[206]" "Low,High"
        bitfld.long 0x00 13. "  SPI[205] ,SPI Status[205]" "Low,High"
        bitfld.long 0x00 12. "  SPI[204] ,SPI Status[204]" "Low,High"
        textline "                 "
        bitfld.long 0x00 11. " SPI[203] ,SPI Status[203]" "Low,High"
        bitfld.long 0x00 10. "  SPI[202] ,SPI Status[202]" "Low,High"
        bitfld.long 0x00 9. "  SPI[201] ,SPI Status[201]" "Low,High"
        bitfld.long 0x00 8. "  SPI[200] ,SPI Status[200]" "Low,High"
        bitfld.long 0x00 7. "  SPI[199] ,SPI Status[199]" "Low,High"
        textline "                 "
        bitfld.long 0x00 6. " SPI[198] ,SPI Status[198]" "Low,High"
        bitfld.long 0x00 5. "  SPI[197] ,SPI Status[197]" "Low,High"
        bitfld.long 0x00 4. "  SPI[196] ,SPI Status[196]" "Low,High"
        bitfld.long 0x00 3. "  SPI[195] ,SPI Status[195]" "Low,High"
        bitfld.long 0x00 2. "  SPI[194] ,SPI Status[194]" "Low,High"
        textline "                 "
        bitfld.long 0x00 1. " SPI[193] ,SPI Status[193]" "Low,High"
        bitfld.long 0x00 0. "  SPI[192] ,SPI Status[192]" "Low,High"                        
tree.end    
tree.end
width 0xb


base ad:(d.l(c15:0x400f))+0x100

width 9. 

tree "Interface Registers"
group.long 0x00++0x03
    line.long 0x00 "ICPICR,CPU Interface Control Register"    
        bitfld.long 0x00 4. " SBPR    ,Controls which Binary Pointer Register" "Non-secured,Secured"
        bitfld.long 0x00 3. "      FIQEN    ,Secure interrupts signal Enable" "nIRQ,nFIQ/secured nIRQ/non-secured"
        textline "                  "
        bitfld.long 0x00 2. " ACKCTL  ,Acknowledge R/W" "Pending/active,Active/Inactive"
        bitfld.long 0x00 1. "  ENABLENS ,Non-secure Interface Enable" "Disabled,Enabled"
        textline "                  "
        bitfld.long 0x00 0. " ENABLES ,Secure Interface Enable" "Disabled,Enabled"
width 9.        
group.long 0x04++0x03
    line.long 0x00 "ICCIPMR,Priority Mask Register"
        bitfld.long 0x00 3.--7. " PMASK   ,Priority Mask" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
group.long 0x08++0x03        
    line.long 0x00 "ICCIBPR,Binary Point Register"
        bitfld.long 0x00 0.--2. " BP      ,Binary Point Mask (Secure/Non-secure)" "0xF8/0xF0,0xF8/0xF0,0xF8/0xF0,0xF0/0xF0,0xE0/0xF0,0xC0/0xE0,0x80/0xC0,0x00/0x80"
rgroup.long 0x0c++0x03
    line.long 0x00 "ICCIAR,Interrupt Acknowledge Register"
        bitfld.long 0x00 10.--12. " CPUS    ,CPU Source ID" "CPU0,CPU1,CPU2,CPU3,?..."
        hexmask.long.word 0x00 0.--9. 1. "         IID      ,Interrupt ID"
wgroup.long 0x10++0x03
    line.long 0x00 "ICCEOIR,End of Interrupt Register"
        bitfld.long 0x00 10.--12. " CPUS    ,CPU Source ID" "CPU0,CPU1,CPU2,CPU3,?..."
        hexmask.long.word 0x00 0.--9. 1. "         IID      ,Interrupt ID"
rgroup.long 0x14++0x03
    line.long 0x00 "ICCRPR,Running Priority Register"
        bitfld.long 0x00 3.--7. " PRIO    ,Priority" "High,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,Low"
rgroup.long 0x18++0x03        
    line.long 0x00 "ICCHPIR,Highest Pending Interrupt Register"
        bitfld.long 0x00 10.--12. " CPUS    ,CPU Source ID" "CPU0,CPU1,CPU2,CPU3,?..."
        hexmask.long.word 0x00 0.--9. 1. "         IID      ,Interrupt ID"
group.long    0x1c++0x03
    line.long 0x00 "ICCABPR,Aliased Non-Secure Binary Point Register"        
group.long 0xfc++0x03
    line.long 0x00 "ICPIIR,CPU Interface Implementer Identification Register"
        hexmask.long.word 0x00 20.--30. 0x1 " PN      ,Identifies the Peripheral"
        bitfld.long 0x00 16.--19. "             AV       ,Identifies the Architecture Version" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "    REV ,Revision number" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.word 0x00 0.--11. 0x1 "  IMP ,Implementer"
tree.end 
width 0xb



width 8. 

tree "Timer and Watchdog Blocks"

base ad:(d.l(c15:0x400f))+0x600

group.long 0x00++0xb "Timer"
    line.long 0x00 "TLR,Timer Load Register"
    line.long 0x04 "TCR,Timer Counter Register"
    line.long 0x08 "TCONR,Timer Control Register"
        hexmask.long.byte 0x08 8.--15. 1. " PRES  ,Prescaler"
        bitfld.long 0x08 3. "         AINC ,Auto Increment" "Single shot,Auto increment"
        bitfld.long 0x08 2. "  IRQEN ,IRQ Enable" "Disabled,Enabled"
        bitfld.long 0x08 1. "  COMPEN ,Comp Enable" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x08 0. " TEN   ,Global Timer Enable" "Disabled,Enabled"
group.long 0x0c++0x3
    line.long 0x00 "TISR,Timer Interrupt Status Register"
        eventfld.long 0x00 0. " EFLAG ,Event Flag" "0,1"
group.long 0x20++0x13 "Watchdog"
    line.long 0x00 "WLR,Watchdog Load Register"
    line.long 0x04 "WCR,Watchdog Counter Register"
    line.long 0x08 "WCONR,Watchdog Control Register"
        hexmask.long.byte 0x08 8.--15. 1. " PRES  ,Prescaler"
        bitfld.long 0x08 3. "         WDM  ,WD Mode" "Timer,Watchdog"
        bitfld.long 0x08 2. "        ITEN  ,IT Enable" "Disabled,Enabled"
        bitfld.long 0x08 1. "  AREL   ,Auto-Reload" "Single shot,Auto-reload"
        textline "                 "
        bitfld.long 0x08 0. " WEN   ,Watchdog Enable" "Disabled,Enabled"
    line.long 0x0c "WISR,Watchdog Interrupt Status Register"
        eventfld.long 0x0C 0. " EFLAG ,Event Flag" "0,1"
    line.long 0x10 "WRSR,Watchdog Reset Sent Register"
        eventfld.long 0x10 0. " RFLAG ,Reset Flag" "No effect,Reset"
wgroup.long 0x34++0x3
    line.long 0x00 "WDR,Watchdog Disable Register"

base ad:(d.l(c15:0x400f))+0x200
    
group.long 0x00++0xb "Global Timer"
    line.long 0x00 "GTLCR,Lower 32-bit Timer Counter Register"
    line.long 0x04 "GTUCR,Upper 32-bit Timer Counter Register"
    line.long 0x08 "GTCONR,Timer Control Register"
        hexmask.long.byte 0x08 8.--15. 1. " PRES  ,Prescaler"
        bitfld.long 0x08 3. "         AINC ,Auto Increment" "Single shot,Auto increment"
        bitfld.long 0x08 2. "  IRQEN ,IRQ Enable" "Disabled,Enabled"
        bitfld.long 0x08 1. "  COMPEN ,Comp Enable" "Disabled,Enabled"
        textline "                 "
        bitfld.long 0x08 0. " TEN   ,Global Timer Enable" "Disabled,Enabled"
group.long 0x0c++0x3
    line.long 0x00 "GTSR,Timer Status Register"
        eventfld.long 0x00 0. " EFLAG ,Event Flag" "0,1"
group.long 0x10++0xb
    line.long 0x00 "GTLCOMR,Lower 32-bit Comparator Register"
    line.long 0x04 "GTUCOMR,Upper 32-bit Comparator Register"
    line.long 0x08 "GTINCR,Auto-increment Register for Comparator"
        
tree.end

width 11.

textline ""
